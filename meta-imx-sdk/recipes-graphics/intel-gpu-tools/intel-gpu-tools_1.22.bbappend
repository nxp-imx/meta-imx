COMPATIBLE_HOST:imxgpu = "aarch64-poky-linux"
