PACKAGE_ARCH:imx-nxp-bsp = "${MACHINE_SOCARCH}"
