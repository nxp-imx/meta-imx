PACKAGECONFIG[PKCS11] = "-F pkcs11-provider,"

