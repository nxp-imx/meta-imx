do_configure() {
}
