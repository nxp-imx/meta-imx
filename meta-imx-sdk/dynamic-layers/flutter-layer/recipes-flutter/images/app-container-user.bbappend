# FIXME: Drop this when meta-flutter is migrated to Styhead
S = "${WORKDIR}/sources"
UNPACKDIR = "${S}"
