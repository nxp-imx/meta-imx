FILESEXTRAPATHS:prepend := "${THISDIR}/flutter-wayland-client:"
SRC_URI += "file://0001-Fix-build-failure-caused-by-GCC-15-changes.patch"
