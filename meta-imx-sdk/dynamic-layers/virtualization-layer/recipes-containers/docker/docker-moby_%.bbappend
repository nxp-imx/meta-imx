SYSTEMD_SERVICE:${PN}:remove = "docker.service"
