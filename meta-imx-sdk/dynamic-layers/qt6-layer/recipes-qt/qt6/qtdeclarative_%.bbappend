INSANE_SKIP:${PN}-ptest += "buildpaths"
