INSANE_SKIP:nativesdk-${PN} += "buildpaths"
INSANE_SKIP:nativesdk-qtgrpc-dev += "buildpaths"
