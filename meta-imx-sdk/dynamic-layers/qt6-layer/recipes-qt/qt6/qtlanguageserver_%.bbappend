INSANE_SKIP:${PN}-dev += "buildpaths"
INSANE_SKIP:${PN}-ptest += "buildpaths"
