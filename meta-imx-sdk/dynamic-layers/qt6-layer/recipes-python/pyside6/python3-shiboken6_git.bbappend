# FIXME: The install does not handle multilib, see https://bugreports.qt.io/browse/PYSIDE-3080
FILES:${PN} += "${exec_prefix}/lib"
