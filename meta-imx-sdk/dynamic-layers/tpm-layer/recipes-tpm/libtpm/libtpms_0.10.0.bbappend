# Bug fixing
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Fixed-discarded-qualifiers-error.patch"
