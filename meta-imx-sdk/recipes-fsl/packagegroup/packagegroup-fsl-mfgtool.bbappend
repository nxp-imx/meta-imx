RDEPENDS:${PN}-base += " \
    gptfdisk \
    hdparm \
    iproute2 \
    nfs-utils \
    simg2img \
    tar \
    zstd \
"

RDEPENDS:${PN}-extfs += " \
    e2fsprogs \
    f2fs-tools \
"
