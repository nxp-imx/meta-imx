FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:imx-nxp-bsp = " file://0001-libnfnetlink-1.0.2-add-non-blocking-mode-and-missing.patch"
