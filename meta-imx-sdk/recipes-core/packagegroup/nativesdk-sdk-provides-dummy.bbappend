DUMMYPROVIDES_PACKAGES:remove = "pkgconfig"
