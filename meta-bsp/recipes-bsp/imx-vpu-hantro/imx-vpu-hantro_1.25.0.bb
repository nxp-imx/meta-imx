# Copyright 2017-2020 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=dedee5689786754f61ea3a76035c8a81"

SRC_URI[md5sum] = "8051dc5e8e9cceba8f8a81402e46c60b"
SRC_URI[sha256sum] = "4e5107198e1779798692a198b223dcda914a5b23e73feb22a046a989bb01044e"
