# Copyright 2017-2020 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=e9e880185bda059c90c541d40ceca922"

SRC_URI[md5sum] = "a1db845a4214197769fe2efb4eb0cd72"
SRC_URI[sha256sum] = "1cb364912e40f30d2420791cb23da943dee6883989bbe9588acef992776df08c"
