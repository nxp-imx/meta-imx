# Copyright 2017-2020 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=1b4db4b25c3a1e422c0c0ed64feb65d2"

SRC_URI[md5sum] = "588ff8853b05426e1ab4c05bf0c51159"
SRC_URI[sha256sum] = "f41cfc3dae3cff999421dbc0bb8bb7b0a985b0b988f047ecdc87ccf2733d1973"
