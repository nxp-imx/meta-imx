# Copyright 2017-2020 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=231e11849a4331fcbb19d7f4aab4a659"

SRC_URI[md5sum] = "556744693135acdf6711a5e85bea3a4d"
SRC_URI[sha256sum] = "419725f0c09f5939c88cd234b729c3943cbd37e53db7352b02c8d6cc05b939b9"
