# Copyright 2017-2020 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=cf3f9b8d09bc3926b1004ea71f7a248a"

SRC_URI[md5sum] = "6777b643fd74ecc2a8b9230a6a1e5a9d"
SRC_URI[sha256sum] = "ae52999d747964dd1bfa41a88b41d29c8cdd5579403cb7e1f00feffb4ec63faa"
