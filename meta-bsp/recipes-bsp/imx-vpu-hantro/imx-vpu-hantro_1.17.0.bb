# Copyright 2017-2019 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"

SRC_URI[md5sum] = "e765592e781e43417071c1ecce3ee955"
SRC_URI[sha256sum] = "c66fca4be1ca1af6777d77c47326b76922a38b2004d180e6c0afb4813746a18e"
