# Copyright 2017-2020 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=228c72f2a91452b8a03c4cab30f30ef9" 

SRC_URI[md5sum] = "50f724eb56bcd57be33766d889994b43"
SRC_URI[sha256sum] = "b4a1c187e6d616cd92306d368034972bcf389fb1b136f8fb725922487885d4b5"
