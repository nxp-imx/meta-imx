# Append path for freescale layer to include updated asound.state
FILESEXTRAPATHS:prepend:mx6 := "${THISDIR}/${PN}/imx:"
FILESEXTRAPATHS:prepend:mx7 := "${THISDIR}/${PN}/imx:"
FILESEXTRAPATHS:prepend:mx8 := "${THISDIR}/${PN}/imx:"
