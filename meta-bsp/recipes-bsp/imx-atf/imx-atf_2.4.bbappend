SRCBRANCH = "lf_v2.4"
ATF_SRC ?= "git://source.codeaurora.org/external/imx/imx-atf.git;protocol=https"
SRC_URI = "${ATF_SRC};branch=${SRCBRANCH}"
SRCREV = "7b75630430a100cc8951bfedcf7f0238f622b7d3"
