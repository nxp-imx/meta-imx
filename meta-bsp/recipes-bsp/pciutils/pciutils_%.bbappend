inherit update-alternatives

ALTERNATIVE:${PN} = "lspci"
ALTERNATIVE_PRIORITY = "100"
