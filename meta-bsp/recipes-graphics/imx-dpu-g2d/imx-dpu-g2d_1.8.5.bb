require recipes-graphics/imx-dpu-g2d/imx-dpu-g2d_1.7.0.bb

LIC_FILES_CHKSUM = "file://COPYING;md5=228c72f2a91452b8a03c4cab30f30ef9"

SRC_URI[md5sum] = "ab5b460594519ce8e5e8c7d3a5755d87"
SRC_URI[sha256sum] = "19bea2b51c16f12a3333c81efedc558768bbeb20af6b3b18689cc42aea345f23"
