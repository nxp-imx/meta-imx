SRC_URI = "git://github.com/KhronosGroup/SPIRV-Headers;protocol=https;branch=main"
