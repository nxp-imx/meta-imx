SRC_URI:remove = "git://github.com/KhronosGroup/SPIRV-Tools.git;branch=master;protocol=https"
SRC_URI:prepend = "git://github.com/KhronosGroup/SPIRV-Tools.git;branch=main;protocol=https "

