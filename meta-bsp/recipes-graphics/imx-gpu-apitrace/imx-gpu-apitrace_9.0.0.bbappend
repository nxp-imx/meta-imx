APITRACE_SRC ?= "git://source.codeaurora.org/external/imx/apitrace-imx.git;protocol=https"
SRCBRANCH = "imx_9.0"
SRC_URI = "${APITRACE_SRC};branch=${SRCBRANCH}"
SRCREV = "c50e6a954e44998f2e3793a8de863e961f8008c6"
