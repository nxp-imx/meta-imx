SRC_URI:remove = "git://github.com/KhronosGroup/glslang.git;protocol=https;branch=master"
SRC_URI:prepend = "git://github.com/KhronosGroup/glslang.git;protocol=https;branch=main "
