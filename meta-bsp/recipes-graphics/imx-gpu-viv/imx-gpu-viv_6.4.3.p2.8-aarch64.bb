require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5a0bf11f745e68024f37b4724a5364fe"

SRC_URI[md5sum] = "c90a4090b6709db97515657cec4fb886"
SRC_URI[sha256sum] = "0f28325a4157b97f53317b02fa285f7556e419d9452f12910cc0fcf843e8afd2"

COMPATIBLE_MACHINE = "(mx8)"
