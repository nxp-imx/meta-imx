require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=2827219e81f28aba7c6a569f7c437fa7" 

IMX_SRCREV_ABBREV = "fc5a04a"

SRC_URI[md5sum] = "6dc3cc30ae77f1a0640fc7d702ceca9a"
SRC_URI[sha256sum] = "c21456c509c50049f4401679a1dc89d57ea6c6b9586d4bab0dd134d2df792751"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
