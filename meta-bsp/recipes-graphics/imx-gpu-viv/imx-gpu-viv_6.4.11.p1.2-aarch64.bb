require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ea25d099982d035af85d193c88a1b479"

SRC_URI[md5sum] = "32eadfd7df841de3336eefd02d0cca60"
SRC_URI[sha256sum] = "8bafc7a3946ceb57bf54cd691d160ec0e3ae1e064e3dd3f787c658447e5a3682"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
