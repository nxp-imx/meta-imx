require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ea25d099982d035af85d193c88a1b479"

SRC_URI[md5sum] = "ceb4b4c5dd38cf1a0d3304d0185e7495"
SRC_URI[sha256sum] = "b8310d198f668f623647ad9b85344aaae4cb5bf8d0460de738d8d0140e50445b"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
