require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a632fefd1c359980434f9389833cab3a"

SRC_URI[md5sum] = "602ddeae55ed7f98990666cd3b5c68d8"
SRC_URI[sha256sum] = "07e9e01c957f4136f238f1e72b63f2fb8135aa09922349d1cb1df5978e611f0b"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
