require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=e565271ec9a80ce47abbddc4bffe56fa" 

SRC_URI[md5sum] = "f77f889d8d2eabf786e60a6e67a74fba"
SRC_URI[sha256sum] = "a3cfc3656b541e3470623d4a9936581d80df5eb9122c2ce2458b787af41035a0"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
