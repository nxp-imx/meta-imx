require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=be5ff43682ed6c57dfcbeb97651c2829"

SRC_URI[md5sum] = "333a44800866cde700cd65c2dfbb5d15"
SRC_URI[sha256sum] = "1b7ffe9ba060243f0c5c0bbfbb431bb1227095579067b38968135dd4974e65a5"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
