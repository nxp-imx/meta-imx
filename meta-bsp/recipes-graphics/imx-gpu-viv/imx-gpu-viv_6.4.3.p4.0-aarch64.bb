require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=17d2319de7baa686e8a755ba58a9ebf5"

SRC_URI[md5sum] = "9498cb68c02d1daaa186f92513b04657"
SRC_URI[sha256sum] = "2949e63a71a883b00caad2ffefad4475c3d0fd28c324f690996af7318619d0e5"

COMPATIBLE_MACHINE = "(mx8)"
