require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5a0bf11f745e68024f37b4724a5364fe"

SRC_URI[md5sum] = "ff0ccd814a9277545d0c0f9ecaf77226"
SRC_URI[sha256sum] = "f0842eb0891a3e0d96c9a92d2868d2b908ea49cee81b185173a78f7fc4572f32"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
