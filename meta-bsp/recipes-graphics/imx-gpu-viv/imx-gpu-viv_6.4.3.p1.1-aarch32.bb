require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cf3f9b8d09bc3926b1004ea71f7a248a" 

SRC_URI[md5sum] = "663de41ee19b79ed5492e18fd8d792e9"
SRC_URI[sha256sum] = "e59a3cfb29a5bf9538eb629c140fbbed7fed02aa128f2407f79b6bbdd1c45217"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
