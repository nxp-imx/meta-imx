require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=db4762b09b6bda63da103963e6e081de"

SRC_URI[md5sum] = "6298d3a3445ef1d761a1edad60905ff9"
SRC_URI[sha256sum] = "9d228cc0c2ef528d6693d76c24b09f96dfa835b5d31c13cec167b6853e749546"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
