require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5a0bf11f745e68024f37b4724a5364fe"

SRC_URI[md5sum] = "98c0d209a6b1d7d179ad51508764a5db"
SRC_URI[sha256sum] = "a721de454cbedd98aa79757fef87dc4cb8c2786b9e8906d7ef787719a2bd4218"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
