require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=417b82f17fc02b88125331ed312f6f1b"

SRC_URI[md5sum] = "664f542ff362cc23c5944433c15edd3c"
SRC_URI[sha256sum] = "5223bddde75bc6b5d13c67816b2601819c276248b376dd14d000919e026bdc29"

COMPATIBLE_MACHINE = "(mx8)"
