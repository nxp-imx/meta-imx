require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cf3f9b8d09bc3926b1004ea71f7a248a"

SRC_URI[md5sum] = "f38322e2c0f4c0b30544440b9bc0921a"
SRC_URI[sha256sum] = "0f007af761c745d8c13075e340762fea8434862d308f85ffe4743f01ec3f9fb3"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
