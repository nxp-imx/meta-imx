require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=983e4c77621568488dd902b27e0c2143"

SRC_URI[md5sum] = "06908eb6df34910e81a1a2916800bc16"
SRC_URI[sha256sum] = "b6f3dd62d5ca979a62b061414c728205e3859819713890154d1cd0b133dac609"

COMPATIBLE_MACHINE = "(mx8)"
