require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=2827219e81f28aba7c6a569f7c437fa7"

IMX_SRCREV_ABBREV = "f8f136f"

SRC_URI[md5sum] = "d351b8522378533981821153c0f06e47"
SRC_URI[sha256sum] = "c31670d3e3f7867efa51cec38576da6828e2b275e3c58f8f06ef261cb40b8996"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
