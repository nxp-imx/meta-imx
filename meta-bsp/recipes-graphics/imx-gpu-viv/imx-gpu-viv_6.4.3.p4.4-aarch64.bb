require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d0122773a9d62bd492c87ffaf42463b5"

SRC_URI[md5sum] = "db5bcbd288f621b35428e5c4d501b260"
SRC_URI[sha256sum] = "b272eee02dfc620e2a97c8a2f48456743963967ba8df6ff7d1f7ca76723cc62d"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
