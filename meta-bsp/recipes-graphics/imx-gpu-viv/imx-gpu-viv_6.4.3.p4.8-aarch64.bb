require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d7853b7bf2936b2c25c893eac7033374"

SRC_URI[md5sum] = "b1c41d3d4b2f78592e8d00d2080b302b"
SRC_URI[sha256sum] = "68e0a9efeff13b1bcd87a52e5b318af5530b09eb5ea3115572ea736dea760838"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
