require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=17d2319de7baa686e8a755ba58a9ebf5"

SRC_URI[md5sum] = "ddafd3b84600e3e539c90660b5873ebb"
SRC_URI[sha256sum] = "5116ff6d7bcf4dff11abebfc3178a2246bd21b2f647e82a9faf28fb8a09b6bdb"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
