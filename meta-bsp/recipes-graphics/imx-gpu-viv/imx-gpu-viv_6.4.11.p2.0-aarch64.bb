require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=9135422c7a38dac21bf1f858b6ef3bac"

IMX_SRCREV_ABBREV = "cb54b23"

SRC_URI[md5sum] = "7f633c5b4885b0fa838c6f2c38692024"
SRC_URI[sha256sum] = "9592608dac18c8798d7c1c9fbf0d2c672d2458d1fdd025b37a10656e60b7df38"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
