require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cf3f9b8d09bc3926b1004ea71f7a248a" 

SRC_URI[md5sum] = "f9ad47ebd024098e46c9dfd9cdf1f4dc"
SRC_URI[sha256sum] = "01190f1fe413519c583345c306a05ed32dee3a8e4142c6c720f19016d25a3760"

COMPATIBLE_MACHINE = "(mx8)"
