require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=2827219e81f28aba7c6a569f7c437fa7"

IMX_SRCREV_ABBREV = "2b0f9a1"

SRC_URI[md5sum] = "363c60a975e2911daecd5283d9f7ada9"
SRC_URI[sha256sum] = "54f8432009edfa896e1cb0a416ee685099c9969fca339a8ff121425f997611be"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
