require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cf3f9b8d09bc3926b1004ea71f7a248a"

SRC_URI[md5sum] = "c595b4e599f5b6a5f3ebf699a939fed4"
SRC_URI[sha256sum] = "ab72e130c3505a6ae60e00dbc4d25f243bccb43c659a5574550afe7d797b3182"

COMPATIBLE_MACHINE = "(mx8)"
