require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d7853b7bf2936b2c25c893eac7033374"

SRC_URI[md5sum] = "125233fbd3f39679df4f60813e5a9faa"
SRC_URI[sha256sum] = "e0c60b385397d09f226b4ea56d160cb629e4e9eeca28bb61a13f147893a0d302"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
