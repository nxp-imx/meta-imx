require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5a0bf11f745e68024f37b4724a5364fe"

SRC_URI[md5sum] = "0c07b3ca32f6112d0784588bbe1fb6f3"
SRC_URI[sha256sum] = "ef67953b54d562eeadbc1b98f86a3fb8e822c84e6b27b4409f943fa6c7c6eb96"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
