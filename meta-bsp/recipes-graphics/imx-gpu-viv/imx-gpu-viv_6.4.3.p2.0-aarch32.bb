require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a632fefd1c359980434f9389833cab3a" 

SRC_URI[md5sum] = "0d2ebb526ad14ec0685b2050068a5b75"
SRC_URI[sha256sum] = "63bf1429b29192b016577a77a4413d6c12eaf1ebcb6186dff583e17ae6dc5550"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
