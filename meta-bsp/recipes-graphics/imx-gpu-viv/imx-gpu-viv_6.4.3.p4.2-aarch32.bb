require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=be5ff43682ed6c57dfcbeb97651c2829"

SRC_URI[md5sum] = "675742df9ccd548a6c0ae7a056deb95b"
SRC_URI[sha256sum] = "d214f9b578c7ce858ae38bacfc7b81062952bd3fea182bd1de516f5d6ad5450e"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
