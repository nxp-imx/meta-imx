require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=3c3fe2b904fd694f28d2f646ee16dddb" 

SRC_URI[md5sum] = "48d3874d304d4d430b0618045fd5fe2d"
SRC_URI[sha256sum] = "84252ed1e8056cb0ae5dca0279755b4fd5a21b69bf48f2f6716434c3c481766f"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
