require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5a0bf11f745e68024f37b4724a5364fe"

SRC_URI[md5sum] = "5e91db0d80746ba8299867a21cd2d0f1"
SRC_URI[sha256sum] = "7bec27859bf75a7ab5e744d4efbed1ee9294c48b288745623e00c754df571a22"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
