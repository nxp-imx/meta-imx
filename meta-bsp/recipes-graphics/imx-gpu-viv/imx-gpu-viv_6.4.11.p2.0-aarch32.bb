require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=673fa34349fa40f59e0713cb0ac22b1f" 

IMX_SRCREV_ABBREV = "395e685"

SRC_URI[md5sum] = "3d1f84ffbaa05abf232fc40fdb39d1a5"
SRC_URI[sha256sum] = "0ee7e867e5256dd48ed154e74e6be74f3013377f1dc93223f8bd844fc09b5942"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
