require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=2827219e81f28aba7c6a569f7c437fa7" 

IMX_SRCREV_ABBREV = "9107682"

SRC_URI[md5sum] = "9c66c5931df6c44d1dca3bbf8734e275"
SRC_URI[sha256sum] = "b367f798530894c91e67bd1b6e18bec33d98d6318b60d40a8490a1258677cc6f"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
