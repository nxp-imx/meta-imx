require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=be5ff43682ed6c57dfcbeb97651c2829"

SRC_URI[md5sum] = "08b56ead3220e92ad4bee742d2005ed8"
SRC_URI[sha256sum] = "64fe458da74a26e0a7bf00386d86d1a748446914ec6b6f3a679c637d916e3e7b"

COMPATIBLE_MACHINE = "(mx8)"
