require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cf3f9b8d09bc3926b1004ea71f7a248a" 

SRC_URI[md5sum] = "7b5f317d1f78cc872379965f79fd6010"
SRC_URI[sha256sum] = "e94e87b5a7df382216340bac06f5d4d87814c7d73464d5ab63deac9217f1bd33"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
