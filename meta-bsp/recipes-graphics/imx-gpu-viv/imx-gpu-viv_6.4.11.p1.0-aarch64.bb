require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=add2d392714d3096ed7e0f7e2190724b"

SRC_URI[md5sum] = "6b174047040352a0b28c1582a086a2da"
SRC_URI[sha256sum] = "1ae2082a4ea56e72ca2016dd9a06df6b3152b494ab4cd7b22409f58034d342e5"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
