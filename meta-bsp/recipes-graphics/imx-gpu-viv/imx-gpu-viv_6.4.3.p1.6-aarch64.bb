require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a632fefd1c359980434f9389833cab3a"

SRC_URI[md5sum] = "3f29b9b8ee325ba97bea36f92cf96545"
SRC_URI[sha256sum] = "11dcaffd88ce589142b4a6df0b8835ebca38b97ba521cba91641038cb315a0f8"

COMPATIBLE_MACHINE = "(mx8)"
