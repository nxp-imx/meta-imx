require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cf3f9b8d09bc3926b1004ea71f7a248a"

SRC_URI[md5sum] = "0f77bd7d535e762220596b60ecf027ac"
SRC_URI[sha256sum] = "e6e8f63476fa2bcce8ca13ab4536e601e9d86184965211289313a058f284ffc9"

COMPATIBLE_MACHINE = "(mx8)"
