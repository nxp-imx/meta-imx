require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=673fa34349fa40f59e0713cb0ac22b1f"

IMX_SRCREV_ABBREV = "02398d3"

SRC_URI[md5sum] = "5bf353d7f40e2c5699e0d5267054957c"
SRC_URI[sha256sum] = "bb94ade0795822c8d027f84c2cb9bd98d04f3a13784c10b7711e167c97ebdccc"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
