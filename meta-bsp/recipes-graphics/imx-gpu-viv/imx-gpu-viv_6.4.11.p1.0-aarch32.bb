require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ea25d099982d035af85d193c88a1b479"

SRC_URI[md5sum] = "62726fd1be2a5580486e7aaecc657008"
SRC_URI[sha256sum] = "689ebfd5c373206188740a5a4e0e676dc9921eede457f5fb827850ad73214a38"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
