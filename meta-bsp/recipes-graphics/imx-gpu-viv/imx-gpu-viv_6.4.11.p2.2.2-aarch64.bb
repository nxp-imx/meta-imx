require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=44a8052c384584ba09077e85a3d1654f"

IMX_SRCREV_ABBREV = "f8f136f"

SRC_URI[md5sum] = "5f2e93de52d42bcbc22b473b2065f953"
SRC_URI[sha256sum] = "9cc86662841539f1b7914921870ca9b7db45643c8680baba974656f24ed11512"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
