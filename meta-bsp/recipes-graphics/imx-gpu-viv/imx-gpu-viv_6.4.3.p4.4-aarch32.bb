require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=be5ff43682ed6c57dfcbeb97651c2829" 

SRC_URI[md5sum] = "60efa96f8a3f2972a352ce03f8387dce"
SRC_URI[sha256sum] = "69adaed4618ca81e21411d5538453b7f7a81d4c5f50ec587ceedf2437f4678cb"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
