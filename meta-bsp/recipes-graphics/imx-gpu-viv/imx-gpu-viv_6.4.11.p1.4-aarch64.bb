require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=673fa34349fa40f59e0713cb0ac22b1f"

IMX_SRCREV_ABBREV = "8bf9562"

SRC_URI[md5sum] = "82cab67eb24b96a0749e7d98a104c9e8"
SRC_URI[sha256sum] = "2859feeeecabfde96491fcb1ff2b7142780a4daaddc3e2ac9c493e2664c5905d"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
