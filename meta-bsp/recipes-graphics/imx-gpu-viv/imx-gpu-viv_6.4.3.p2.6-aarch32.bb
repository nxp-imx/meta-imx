require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d3c315c6eaa43e07d8c130dc3a04a011"

SRC_URI[md5sum] = "5d39fbb40ca9c98854b9fe71bfd8d4cc"
SRC_URI[sha256sum] = "519711463880875e372392dcc1d8653fb86ec3e3dc2999fec722bc0c6127e0da"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
