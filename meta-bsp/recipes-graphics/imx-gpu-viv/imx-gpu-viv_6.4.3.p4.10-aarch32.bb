require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=673fa34349fa40f59e0713cb0ac22b1f"

SRC_URI[md5sum] = "ccfc078eedcac90a60292689c550a1c9"
SRC_URI[sha256sum] = "02a3fb590fec06b1e52786ac419e7bf14dff5759fb7dd6b9d4ca5fe0890e3e25"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
