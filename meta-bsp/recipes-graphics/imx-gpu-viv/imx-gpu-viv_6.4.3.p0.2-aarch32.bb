require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=1b4db4b25c3a1e422c0c0ed64feb65d2"

SRC_URI[md5sum] = "e20a25a09cb87e94016e1bdd030b76b0"
SRC_URI[sha256sum] = "de71482534e314092349606f0899bf262c10d1117cd1810e2563f196d4348005"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
