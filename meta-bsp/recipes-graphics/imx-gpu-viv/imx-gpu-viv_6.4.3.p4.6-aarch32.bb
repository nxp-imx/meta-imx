require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5a0bf11f745e68024f37b4724a5364fe"

SRC_URI[md5sum] = "47f2eb7c911dd89e0a472ac5645fd97f"
SRC_URI[sha256sum] = "2940199be8203c3f0a3ab384d65f9c75f9cca5e43883929829dcef59520704f1"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
