require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=28241cb895217d7946e40e7227136d02"

SRC_URI[md5sum] = "1555b8fcc51f43d1bd7b55147d5cc29b"
SRC_URI[sha256sum] = "b52a4aabf1a48daee8112fa02bd0e22011db8044b4f563b265f90e8975d7bc31"

COMPATIBLE_MACHINE = "(mx8)"
