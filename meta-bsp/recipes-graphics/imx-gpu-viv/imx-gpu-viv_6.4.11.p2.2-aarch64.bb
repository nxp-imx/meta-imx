require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=2827219e81f28aba7c6a569f7c437fa7"

IMX_SRCREV_ABBREV = "b61e5e2"

SRC_URI[md5sum] = "e3c12ed2dccc011e8837af9d50e38c93"
SRC_URI[sha256sum] = "ac14f1cac6e4b8d3dcd7157eec4b41e869922afd468afe7a1822bd3a3ea2e38d"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
