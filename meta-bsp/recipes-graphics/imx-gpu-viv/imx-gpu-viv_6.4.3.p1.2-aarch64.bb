require imx-gpu-viv-6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cf3f9b8d09bc3926b1004ea71f7a248a" 

SRC_URI[md5sum] = "499a6774c85549129ea78e590c9efef6"
SRC_URI[sha256sum] = "6f7b227373e648e622fe666ce283ea9659bf4eab57e751a3f831046c3704551f"

COMPATIBLE_MACHINE = "(mx8)"
