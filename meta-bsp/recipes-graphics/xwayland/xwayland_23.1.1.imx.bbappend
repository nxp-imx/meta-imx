OPENGL_PKGCONFIGS_REMOVE_IMXGPU:mx95-nxp-bsp = "glamor glx"
