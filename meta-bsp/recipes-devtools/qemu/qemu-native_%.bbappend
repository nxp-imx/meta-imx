FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0011-linux-user-remove-host-stime-syscall.patch"

