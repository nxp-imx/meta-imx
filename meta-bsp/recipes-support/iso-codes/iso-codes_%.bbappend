# Add Patch as master is delete and replace with main branch
SRC_URI = "git://salsa.debian.org/iso-codes-team/iso-codes.git;protocol=http;branch=main"
