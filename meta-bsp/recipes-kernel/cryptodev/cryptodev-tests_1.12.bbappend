FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
file://0001-tests-Makefile-do-not-use-Werror.patch \
"
