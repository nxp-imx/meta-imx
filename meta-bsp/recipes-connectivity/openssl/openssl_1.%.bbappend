PACKAGECONFIG += "cryptodev-linux"

EXTRA_OECONF_append = " enable-engine enable-dso enable-afalgeng"
