# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=17d2319de7baa686e8a755ba58a9ebf5"

SRC_URI[md5sum] = "fdafda77b474713dacdbf041cd6006bd"
SRC_URI[sha256sum] = "58acd52c4ca15c23acbbd7a719a5618ffb6711e9bdc5b47a3a569fe03dd36704"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
