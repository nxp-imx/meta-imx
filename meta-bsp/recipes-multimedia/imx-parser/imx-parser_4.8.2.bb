include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=2827219e81f28aba7c6a569f7c437fa7"

SRC_URI[md5sum] = "4208bb74a6e58be3012e46ea3ee8839f"
SRC_URI[sha256sum] = "8948dddc3184ab7bf591a71d114d0c295fb6a46f272b774e6fa1ee1f59f9bd10"
