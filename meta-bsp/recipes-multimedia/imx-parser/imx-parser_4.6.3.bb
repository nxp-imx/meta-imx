# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=28241cb895217d7946e40e7227136d02"

SRC_URI[md5sum] = "985ffbce33145cc63a87feb37e27be4f"
SRC_URI[sha256sum] = "5b66c0a1cc94895a40436405d6cea332264079bc18d7ff839049fa1c9865f311"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
