include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5a0bf11f745e68024f37b4724a5364fe"

SRC_URI[md5sum] = "ea7e9cb5c77cb3070a7988cf5f675dbb"
SRC_URI[sha256sum] = "75222833f16f5a13bf0742b818936af450597ef18f7cc51a65fdb6967435f33b"
