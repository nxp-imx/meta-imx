# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"

SRC_URI[md5sum] = "142523593389daffa246ca2aa2545904"
SRC_URI[sha256sum] = "303ea65db499150b733d21623641efbca0f888ba8618a0c1195f8aad736b3800"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
