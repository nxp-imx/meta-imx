# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=231e11849a4331fcbb19d7f4aab4a659"

SRC_URI[md5sum] = "5e72bee9ff7a777597849d296e374675"
SRC_URI[sha256sum] = "a312e42b79f07a9646033dc0c9b65cb00accb8c2aac041e7c0f05b5c3e093560"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
