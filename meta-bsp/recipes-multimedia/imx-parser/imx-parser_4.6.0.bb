# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cf3f9b8d09bc3926b1004ea71f7a248a" 

SRC_URI[md5sum] = "c1209f97cd3bb24ae0cfa7586e4d31d6"
SRC_URI[sha256sum] = "76490fb33b668ab19c995660e5c1abcf554b0884cedfc0e52660a624b0f12f1e"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
