include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=2827219e81f28aba7c6a569f7c437fa7" 

SRC_URI[md5sum] = "08c1d7554bc40aef02799ff15afc32d7"
SRC_URI[sha256sum] = "426592b662a21f0bd7ecf3dfefd4f3b8860d7bfb76e00ae64be8bf6e5686cb82"
