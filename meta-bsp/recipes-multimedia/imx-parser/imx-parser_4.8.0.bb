include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d7853b7bf2936b2c25c893eac7033374" 

SRC_URI[md5sum] = "5acc272c6227bdde1c686487815d6f3c"
SRC_URI[sha256sum] = "01cf44206ae63c9e1f682c1dab04059b842f52414cd2bbc9ddb3f93e2e8043e5"
