# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=228c72f2a91452b8a03c4cab30f30ef9" 

SRC_URI[md5sum] = "2c2f1e61274b41a9a92b3d6447af3c04"
SRC_URI[sha256sum] = "bbd467cb8d9f8a808e7fe3f3ee3601974a51cce14a94bfa328f7c864330e0066"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
