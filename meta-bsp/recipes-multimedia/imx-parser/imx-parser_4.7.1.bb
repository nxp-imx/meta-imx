# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=b54da624b8d2ffe8a3b47757da48e60f"

SRC_URI[md5sum] = "5f11971fa79d737315148de00bc5df0a"
SRC_URI[sha256sum] = "d54eb16233cd244fa2cb714ef3e9d3f5ac9c4863221ea57b289cd1896d4eccaf"

COMPATIBLE_MACHINE = "(imx-nxp-bsp)"
