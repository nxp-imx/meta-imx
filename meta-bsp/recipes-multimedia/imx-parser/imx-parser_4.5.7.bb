# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=983e4c77621568488dd902b27e0c2143"

SRC_URI[md5sum] = "39eab956fa00787dc68f88998f0fd2f3"
SRC_URI[sha256sum] = "1c1ed4fd84f115a1dc712f5f3ddcaa3791193538a55928c4c48f1085f0237798"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
