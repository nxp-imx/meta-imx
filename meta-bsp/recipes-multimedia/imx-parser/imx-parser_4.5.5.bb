# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=228c72f2a91452b8a03c4cab30f30ef9"

SRC_URI[md5sum] = "194230731b4fa0d18f4c7f9862f6b34f"
SRC_URI[sha256sum] = "55c34220cf6d789407f00297265868b0952774cf3c78147b1b67bae2d56935ca"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
