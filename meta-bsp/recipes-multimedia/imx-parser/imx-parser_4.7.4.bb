include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ea25d099982d035af85d193c88a1b479"

SRC_URI[md5sum] = "df3fc6032f076035c06fce70ffcd712e"
SRC_URI[sha256sum] = "2e84b017ff0999454d513d2df6e2e440c62c6aa70ec81b2464ef37187d0df5fc"
