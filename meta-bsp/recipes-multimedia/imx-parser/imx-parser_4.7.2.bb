# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=65c483bb431ccd9a1820e6872c604771" 

SRC_URI[md5sum] = "2fa83cc5814cc04a7e8120b1ad5663b6"
SRC_URI[sha256sum] = "8a04f7841dc16e879a7a2629c11a83e2d9e718c9eb511026df784d7ff6e1fcb2"

COMPATIBLE_MACHINE = "(imx-nxp-bsp)"
