# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=be5ff43682ed6c57dfcbeb97651c2829" 

SRC_URI[md5sum] = "93779eedf132240e34e77852259d9790"
SRC_URI[sha256sum] = "4e7798b42b67b8dcc0af4ba2be912772f711df9d2362359093c8dd9fe41f49a2"

COMPATIBLE_MACHINE = "(imx-nxp-bsp)"
