include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=673fa34349fa40f59e0713cb0ac22b1f"

SRC_URI[md5sum] = "fdcbe05e54bcedd8d3437d9e5b3cf559"
SRC_URI[sha256sum] = "6319992e3be1ff5677a5ac46783bcee83497b380a2bb483e1f7d81a3f6e0e222"
