# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=dedee5689786754f61ea3a76035c8a81"

SRC_URI[md5sum] = "d12cf1708da917a15871227b73f69306"
SRC_URI[sha256sum] = "c0996b0d1ad9d1c76d04caf8a24ad11f3d1f17bb904f077846aea462675be05d"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
