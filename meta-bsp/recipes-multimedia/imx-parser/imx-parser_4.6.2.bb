# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=b3b0bab6ff55420d043cf1652c52d788"

SRC_URI[md5sum] = "fd2ebd0d6f21a8392865b1fdc70bc64f"
SRC_URI[sha256sum] = "a708244b75256144d28ed65f6dc0897b90e6c066937f887d5e17c1d334127e89"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
