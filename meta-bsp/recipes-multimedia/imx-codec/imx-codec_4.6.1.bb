# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cf3f9b8d09bc3926b1004ea71f7a248a"

SRC_URI[md5sum] = "abf4ef9fb71ed1fd5b7797ad25451b08"
SRC_URI[sha256sum] = "05779a6653dbad37612f10536501e1ae4dbc286d2695cee2ae750618e086427c"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
