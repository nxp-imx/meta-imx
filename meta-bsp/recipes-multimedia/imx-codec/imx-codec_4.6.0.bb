# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cf3f9b8d09bc3926b1004ea71f7a248a"

SRC_URI[md5sum] = "103fa6f4f0d61030e28f007188362073"
SRC_URI[sha256sum] = "2b519a39d4fad9a2a56807fecade837ebc107e7354604afaf2990503a018fd4a"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
