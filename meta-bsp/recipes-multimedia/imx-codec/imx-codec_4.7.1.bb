# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=d3c315c6eaa43e07d8c130dc3a04a011"

SRC_URI[md5sum] = "e86da4c53eef10bcd8d5b27a8cff8cea"
SRC_URI[sha256sum] = "8adf2e6d30be10d75bf5c7967d23801d99a93763423cbdb75e1d9d2778e2e175"

COMPATIBLE_MACHINE = "(imx-nxp-bsp)"
