# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=dedee5689786754f61ea3a76035c8a81" 

SRC_URI[md5sum] = "ac065634686f3edbe15409aaf5cbf38f"
SRC_URI[sha256sum] = "61af31aa4182ade06ea52b1af41081f893d942b102a494bf94a7fbbedfaafe2f"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
