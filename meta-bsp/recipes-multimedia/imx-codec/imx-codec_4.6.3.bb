# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=28241cb895217d7946e40e7227136d02"

SRC_URI[md5sum] = "f4b85212470daa797c91d2142faa493b"
SRC_URI[sha256sum] = "8203956cddb3cac560efafcc60e8cab07dded8fea53bd144576d1ae6f3269826"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
