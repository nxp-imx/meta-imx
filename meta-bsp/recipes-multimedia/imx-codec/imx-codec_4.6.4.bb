# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=dedee5689786754f61ea3a76035c8a81"

SRC_URI[md5sum] = "cd04aa811d30b7b492a4e89c6f82b338"
SRC_URI[sha256sum] = "8f40a4f88212762d7f986718f2aa7605c9ddff5b9a751fac0c8327889266b3b4"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
