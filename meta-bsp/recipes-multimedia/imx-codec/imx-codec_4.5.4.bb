# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=228c72f2a91452b8a03c4cab30f30ef9"

SRC_URI[md5sum] = "15723dd29447dfda4038a76a1d911a6a"
SRC_URI[sha256sum] = "88d0147124d40edce39c7a45aebdb0157f6595009da3b873ce9a1fd69bb97ca1"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
