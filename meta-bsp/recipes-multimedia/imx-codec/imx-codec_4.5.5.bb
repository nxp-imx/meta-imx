# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=228c72f2a91452b8a03c4cab30f30ef9"

SRC_URI[md5sum] = "ac129ac82f816b0584aad6980bb39081"
SRC_URI[sha256sum] = "cb6869efc51fe0ea02be4bb4cdbc6aef051b5c18ed939548306a71270b82a035"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
