# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=1b4db4b25c3a1e422c0c0ed64feb65d2"

SRC_URI[md5sum] = "d3cbbc008bed4a95ca992051c098004a"
SRC_URI[sha256sum] = "1e5ef55680ee665d59e140f2a38aa9418518069eb78b3eb0af4ec22ac515c167"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
