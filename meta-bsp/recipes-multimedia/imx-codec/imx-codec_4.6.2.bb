# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=85d06b38f17b935ca11784d67075b846"

SRC_URI[md5sum] = "ff52c8805eeae8b9a697888a9ed200f2"
SRC_URI[sha256sum] = "696b541d91b7382d9a6b3ed801c1d325af3156ca11e1e9eb055c8470d6707f72"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
