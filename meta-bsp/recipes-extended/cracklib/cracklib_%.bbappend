SRC_URI:remove = "git://github.com/cracklib/cracklib;protocol=https;branch=master"
SRC_URI:prepend = "git://github.com/cracklib/cracklib;protocol=https;branch=main "
