# Copyright (C) 2022 NXP
require optee-os.imx.inc

SRCBRANCH = "lf_3.17.y"
SRCREV = "ba3f9137c176292f29d6c0ea5f9b43e57bb37531"
