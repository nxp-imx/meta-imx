# Copyright (C) 2019 NXP
require optee-client.imx.inc

SRCBRANCH = "imx_3.2.y"
SRCREV = "bc0ec8ce1e4dc5ae23f4737ef659338b7cd408fe"


