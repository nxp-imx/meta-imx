# Copyright (C) 2019-2020 NXP
require optee-os.imx.inc

SRCBRANCH = "imx_3.7.y"
SRCREV = "b42e21674db6af9132b45309d8512eed5d2c1835"
