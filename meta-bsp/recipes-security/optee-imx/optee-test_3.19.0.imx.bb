# Copyright (C) 2022 NXP
require optee-test.imx.inc

SRCBRANCH = "lf_3.19.y"
SRCREV = "575f0387b3af48a6c64f02012b66f9f56df9c1ca"
