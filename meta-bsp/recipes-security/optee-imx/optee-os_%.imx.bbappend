inherit features_check

REQUIRED_MACHINE_FEATURES = "optee"
