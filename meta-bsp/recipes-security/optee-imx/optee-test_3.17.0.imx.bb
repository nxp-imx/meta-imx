# Copyright (C) 2022 NXP
require optee-test.imx.inc

SRCBRANCH = "lf_3.17.y"
SRCREV = "41222c4b8df1adc0f0bdc737e5cb824becd25f63"
