# Copyright (C) 2021 NXP
require optee-client.imx.inc

SRCBRANCH = "master"
SRCREV = "f6e05d3d614e5abffd1bc34561d4724773c063be"