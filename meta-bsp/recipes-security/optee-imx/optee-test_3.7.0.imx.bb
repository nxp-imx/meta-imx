# Copyright (C) 2020 NXP
require optee-test.imx.inc

SRCBRANCH = "imx_3.7.y"
SRCREV = "b1613e2f770fd0168d25703fc4adfd3539425fe7"
