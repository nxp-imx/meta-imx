# Copyright (C) 2022 NXP
require optee-client.imx.inc

SRCBRANCH = "lf_3.17.y"
SRCREV = "9d8f1903bbea3a1e631c8d26ee51c37020569312"
