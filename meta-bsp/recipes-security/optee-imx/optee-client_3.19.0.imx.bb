# Copyright (C) 2022 NXP
require optee-client.imx.inc

inherit pkgconfig

DEPENDS = "util-linux-libuuid"

SRCBRANCH = "lf_3.19.y"
SRCREV = "140bf463046071d3ca5ebbde3fb21ee0854e1951"
