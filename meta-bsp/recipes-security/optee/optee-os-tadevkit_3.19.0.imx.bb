require optee-os-tadevkit-imx.inc

SRCBRANCH = "lf_3.19.y"
SRCREV = "b351856ace96c06b8237765702993ca5da2cbbb6"
