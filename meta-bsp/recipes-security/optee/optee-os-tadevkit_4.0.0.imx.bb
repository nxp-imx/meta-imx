require optee-os-tadevkit-imx.inc

SRCBRANCH = "lf-6.1.55_2.2.0"
SRCREV = "a303fc80f7c4bd713315687a1fa1d6ed136e78ee"
