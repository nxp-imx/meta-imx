require optee-test-imx.inc

SRCBRANCH = "lf_3.21.y"
SRCREV = "ffb06949ae5205ed2f545dbc6595a113d2cec331"
