require optee-os-tadevkit-imx.inc

SRCBRANCH = "lf_3.21.y"
SRCREV = "41ad86a019a8088d33c6b517ced67a2d05946892"
