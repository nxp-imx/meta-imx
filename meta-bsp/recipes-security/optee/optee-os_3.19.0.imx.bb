require optee-os-imx.inc

SRCBRANCH = "lf-6.1.1_1.0.0"
SRCREV = "f9143cad95c46f3d793e427fca6e25e7abb8a069"
