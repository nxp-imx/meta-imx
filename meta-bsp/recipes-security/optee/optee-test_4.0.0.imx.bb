require optee-test-imx.inc

SRCBRANCH = "lf-6.1.55_2.2.0"
SRCREV = "62a5d00eed24f40402226c6238298721b8f4bae2"
