require optee-os-imx.inc

SRCBRANCH = "lf_4.0.y"
SRCREV = "d2fa5bed81d7aa60fdeecb5777614831441cadb2"
