require optee-os-imx.inc

SRCBRANCH = "lf_3.21.y"
SRCREV = "b2c53ffbc0c3858ae619074710d8a052c184367c"
