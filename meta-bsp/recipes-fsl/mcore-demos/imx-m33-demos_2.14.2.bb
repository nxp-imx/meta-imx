# Copyright 2023 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx93-nxp-bsp = "file://COPYING;md5=2827219e81f28aba7c6a569f7c437fa7"


SRC_URI[imx93.md5sum] = "824aa0e041f65ac1c27c7529fa3d0d9e"
SRC_URI[imx93.sha256sum] = "e3019b40b2af3dfa9f3a8401d29046d5043f32ce775a28416f0f50acc133cff5"

COMPATIBLE_MACHINE = "(mx93-nxp-bsp)"
