# Copyright 2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=e565271ec9a80ce47abbddc4bffe56fa"

SRC_URI[imx8ulp.md5sum] = "5c527fa8f0185099790361dc6132989c"
SRC_URI[imx8ulp.sha256sum] = "76b2a5625d20b09dd0d9df4aad4f028f7096a674a0d33d9d0ef3fd474afa423c"

COMPATIBLE_MACHINE = "(mx8ulp)"
