# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos-2.8.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cf3f9b8d09bc3926b1004ea71f7a248a"

SRC_URI[imx8mm.md5sum] = "19c16b17e1891bfb7cada584ee080928"
SRC_URI[imx8mm.sha256sum] = "22fb89c289b720aa6b371ca13f4892b681a9812104b6af44a30d4e65f1f51b60"

COMPATIBLE_MACHINE = "(mx8mm)"
