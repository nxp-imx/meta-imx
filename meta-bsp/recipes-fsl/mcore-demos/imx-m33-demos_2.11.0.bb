# Copyright 2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=28241cb895217d7946e40e7227136d02"

SRC_URI[imx8ulp.md5sum] = "a1decddf387af564c06b2f2a7823d0bd"
SRC_URI[imx8ulp.sha256sum] = "8b1d8c04108b737e028f40b5eeefebee894f4c96303ba86959c278e5a72a3239"

COMPATIBLE_MACHINE = "(mx8ulp)"
