# Copyright 2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=dedee5689786754f61ea3a76035c8a81"

SRC_URI[imx8ulp.md5sum] = "fb87ff0853a1ec07b20b16e0d122d53b"
SRC_URI[imx8ulp.sha256sum] = "ba88b378f3637ebf5194c62174321f2fc693742d2669ed40129bd3009f542dd7"

COMPATIBLE_MACHINE = "(mx8ulp)"
