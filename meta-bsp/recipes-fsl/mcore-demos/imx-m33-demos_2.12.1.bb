# Copyright 2022 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=be5ff43682ed6c57dfcbeb97651c2829"

SRC_URI[imx8ulp.md5sum] = "6ac16928ac5ae6e06a3e32edc6832dd7"
SRC_URI[imx8ulp.sha256sum] = "aa514f5e83ff4c2b8bd2037cc8a18ae7fb8cc33c4c052821650413605edecea1"

COMPATIBLE_MACHINE = "(mx8ulp-nxp-bsp)"
