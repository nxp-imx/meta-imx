# Copyright 2022 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx8ulp-nxp-bsp = "file://COPYING;md5=5a0bf11f745e68024f37b4724a5364fe"

SRC_URI[imx8ulp.md5sum] = "8fa4f26d623dbbeb9d6c77035edd2d60"
SRC_URI[imx8ulp.sha256sum] = "3914c6c3e89b055227efb36a998cff9176232346b7b9d5f9c89ef7ad6f968751"

COMPATIBLE_MACHINE = "(mx8ulp-nxp-bsp)"
