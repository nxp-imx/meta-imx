# Copyright 2019-2020 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos-2.8.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=1b4db4b25c3a1e422c0c0ed64feb65d2"

SRC_URI[imx8mn.md5sum] = "3beaedc3fde76585551890df2659e61b"
SRC_URI[imx8mn.sha256sum] = "13ce4a19d51e19cfdee9203a943a57637d001840fe546cacb5a5c741e66bbb43"

COMPATIBLE_MACHINE = "(mx8mn)"
