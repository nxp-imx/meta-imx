# Copyright 2017-2020 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos-2.8.inc

LIC_FILES_CHKSUM_mx8qxp = "file://COPYING;md5=228c72f2a91452b8a03c4cab30f30ef9"
LIC_FILES_CHKSUM = "file://COPYING;md5=983e4c77621568488dd902b27e0c2143"

SRC_URI[imx8dxl.md5sum] = "c07c365c009800a38566c3ed853b2763"
SRC_URI[imx8dxl.sha256sum] = "30e32a346b8f4e13b4560454911e85a5fc32825654d5c88ebd3833c2d0f50651"

COMPATIBLE_MACHINE = "(mx8dxl)"
