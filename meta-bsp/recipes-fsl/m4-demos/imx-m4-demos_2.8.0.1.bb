# Copyright 2017-2021 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos-2.8.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a632fefd1c359980434f9389833cab3a" 

SRC_URI[imx7ulp.md5sum] = "e08d9dd060ad7da050b169d81492e163"
SRC_URI[imx7ulp.sha256sum] = "079b84263b5522711a31acec9d290e8843c002fd5b314e5a9a1fddee9c039aa6"

COMPATIBLE_MACHINE = "(mx7ulp)"
