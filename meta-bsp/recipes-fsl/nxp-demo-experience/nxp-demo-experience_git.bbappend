RDEPENDS:${PN}:remove = "weston"
