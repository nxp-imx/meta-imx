PACKAGECONFIG:append:mx8-nxp-bsp = " tracer-hooks"
PACKAGECONFIG:append:mx9-nxp-bsp = " tracer-hooks"
