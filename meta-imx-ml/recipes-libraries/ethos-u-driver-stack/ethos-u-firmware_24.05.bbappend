
SRCBRANCH = "lf-6.18.37_2.1.0"
SRCREV = "a048dc452774568f2e84b620fae849ebb975be4c"
