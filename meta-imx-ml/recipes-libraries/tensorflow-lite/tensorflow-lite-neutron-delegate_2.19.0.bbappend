
require tensorflow-lite-${PV}.inc

SRCBRANCH_neutron = "main"
SRCREV_neutron = "cdceeee55902861617a766a2e5389a6df25133ab"
