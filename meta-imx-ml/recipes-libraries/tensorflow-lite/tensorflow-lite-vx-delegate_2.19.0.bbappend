
require tensorflow-lite-${PV}.inc

SRCBRANCH_vx = "lf-6.18.37_2.1.0"
SRCREV_vx = "a8c06bb2cc656f6245fd6ec8f2dcd71485ae96d1"
