
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=bc649096ad3928ec06a8713b8d787eac"

SRCBRANCH = "main"
SRCREV = "4bd0b7c34f1ca2fd8765e0c255d45fe90b97fb32"

NEUTRON_TARGET:mx943-nxp-bsp = "imx943"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp|mx95-nxp-bsp)"
