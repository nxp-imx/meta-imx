
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=bc649096ad3928ec06a8713b8d787eac"

SRCBRANCH = "lf-6.12.49_2.2.0"
SRCREV = "2b53896dc448bbcc5e22c2366182962f32e11ce5"

NEUTRON_TARGET:mx943-nxp-bsp = "imx943"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp|mx95-nxp-bsp)"
