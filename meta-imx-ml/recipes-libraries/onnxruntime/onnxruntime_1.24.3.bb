require onnxruntime.inc

SRCBRANCH = "imx_1.24.3"
SRCREV = "0bf7f011b67e5d93a651ca97b13a94d783aff2c6"

