# Use NXP latest version

SRCBRANCH ?= "2023.11.imx"
SRCREV = "3c240419eed3e8fec9981e332750845b5be28da2"
