FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

SRC_URI += "file://epdc-Rename-mxcfb_epdc_kernel.h-to-mxc_epdc.h.patch "
