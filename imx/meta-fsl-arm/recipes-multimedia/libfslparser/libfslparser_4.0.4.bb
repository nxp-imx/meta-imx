# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslparser/libfslparser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=acdb807ac7275fe32f9f64992e111241"

SRC_URI[md5sum] = "7914ed662e357f8edfec8b38e12addd1"
SRC_URI[sha256sum] = "933efe78f0a992a4b946d310b9b04a065602fd9d44c52086a9d51124a0b55339"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7)"
