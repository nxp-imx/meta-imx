# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslparser/libfslparser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=acdb807ac7275fe32f9f64992e111241"

SRC_URI[md5sum] = "3a19d545e6391365af8a0dfb3d6a2d46"
SRC_URI[sha256sum] = "0d8123b469786964aa45bb7a681f9e0d6a3cb3f92f5ccd40edeb66fb65eb917a"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7)"
