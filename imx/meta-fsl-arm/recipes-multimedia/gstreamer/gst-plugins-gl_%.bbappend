# gst-plugins-gl for imx6 Vivante

DEPENDS_remove_mx6 = "gpu-viv-bin-mx6q"

DEPENDS_append_mx6 = " gpu-viv-bin"


