# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslcodec/libfslcodec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=acdb807ac7275fe32f9f64992e111241"

SRC_URI[md5sum] = "ce74c62cae1c36fc9e4a20a272340c7c"
SRC_URI[sha256sum] = "0970b549c7ac767db234e72b5bc9223cb44a205c23f24379eab782073b3685fe"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7)"
