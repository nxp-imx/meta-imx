# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslcodec/libfslcodec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=acdb807ac7275fe32f9f64992e111241"

SRC_URI[md5sum] = "53f5f42c4b1855796ac5ad6fe0eea108"
SRC_URI[sha256sum] = "d220574dfd92c6dfafb0c55a1720c0b7a3fae0b7b883d8e8a012e5f188e8093d"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7)"
