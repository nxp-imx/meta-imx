# fsl-alsa-plugins for MX6 Kernel 3.10.9 

INCLUDE_DIR = "-I${STAGING_KERNEL_DIR}/include/uapi -I${STAGING_KERNEL_DIR}/include"

