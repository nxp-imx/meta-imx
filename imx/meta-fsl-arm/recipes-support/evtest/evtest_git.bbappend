SRC_URI = "git://git.freedesktop.org/evtest;protocol=http"
