FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://use_cryptodev_1.6.patch "
