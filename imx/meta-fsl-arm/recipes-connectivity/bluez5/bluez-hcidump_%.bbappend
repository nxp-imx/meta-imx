DEPENDS = "virtual/bluez"
