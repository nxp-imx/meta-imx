
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-gdb-fix-the-package-too-long-issue.patch"

