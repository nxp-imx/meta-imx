
FILESEXTRAPATHS_prepend := "${THISDIR}/gcc-4.8:"

SRC_URI += "file://0048-PR57532.patch \
"
