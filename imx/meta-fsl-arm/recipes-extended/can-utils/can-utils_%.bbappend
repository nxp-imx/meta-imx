SRC_URI = "git://github.com/linux-can/can-utils/${BPN}.git;protocol=https;branch=master"

