SRC_URI = "git://git.gitorious.org/linux-can/${BPN}.git;protocol=https;branch=master"
