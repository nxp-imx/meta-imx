# Copyright (C) 2013-2015 Freescale Semiconductor

require recipes-bsp/imx-vpu/imx-vpu.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=acdb807ac7275fe32f9f64992e111241"

PE = "1"

SRC_URI[md5sum] = "2b892e61887c72039c7c37b97d986933"
SRC_URI[sha256sum] = "3fcb755f272fed2f4af4bebc39e38c276eb9123ab3cdec7182458c67aab6e125"

COMPATIBLE_MACHINE = "(mx6)"
