# Copyright (C) 2013-2015 Freescale Semiconductor

require recipes-bsp/imx-vpu/imx-vpu.inc
LIC_FILES_CHKSUM = "file://EULA.txt;md5=acdb807ac7275fe32f9f64992e111241"

PE = "1"

SRC_URI[md5sum] = "7cfa4696dbc3cbf159784299f6ff0251"
SRC_URI[sha256sum] = "659cbba8067a1c3d16007d2287d19da2ebfc034f659f1ba689905cecc353fbf9"

COMPATIBLE_MACHINE = "(mx6)"
