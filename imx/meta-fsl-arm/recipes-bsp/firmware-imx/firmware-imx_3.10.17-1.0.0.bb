# Copyright (C) 2012-2014 Freescale Semiconductor

require recipes-bsp/firmware-imx/firmware-imx.inc

PE="1"

SRC_URI[md5sum] = "047cdc089c5aabe7eb78a6e46aa90986"
SRC_URI[sha256sum] = "065a254cd3bf7ebac1a9c2d355eb652bb628b03183cc87d2fcc52736ee712c99"

COMPATIBLE_MACHINE = "(mx6)"
