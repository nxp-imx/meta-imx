SRC_URI = "${FSL_MIRROR}/imx-kobs-${PV}.tar.gz"
S="${WORKDIR}/${PN}-${PV}"

SRC_URI[md5sum] = "df477a6ce9abfa3077fa1a7bb97942e1"
SRC_URI[sha256sum] = "9458bac13a8e58e3d13cb2861d2b3d2cffd990e675c919c65548b71b6dda2776"
