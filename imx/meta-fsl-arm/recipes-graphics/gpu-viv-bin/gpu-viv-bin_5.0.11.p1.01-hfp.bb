# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require gpu-viv-bin.inc

S="${WORKDIR}/${PN}-${PV}"

SRC_URI[md5sum] = "783be655a11695e22a8e8f041f23f7aa"
SRC_URI[sha256sum] = "e7d858e165766248a61bf3ca0542c95fe8d3b027c8ec77b5d5c17c9b24845c24"

PACKAGE_FP_TYPE = "hardfp"
