# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require gpu-viv-bin.inc

S="${WORKDIR}/${PN}-${PV}"

SRC_URI[md5sum] = "fa45c948b96996da472d6a7cfa15ca0f"
SRC_URI[sha256sum] = "e2d39d83dadc0d21b08de1b49ff22d4e3ce6f0ed4ae6b70957df522ef8fd7b5d"

PACKAGE_FP_TYPE = "hardfp"
