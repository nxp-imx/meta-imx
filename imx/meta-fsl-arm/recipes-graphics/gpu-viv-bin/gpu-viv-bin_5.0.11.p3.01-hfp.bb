# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require gpu-viv-bin.inc

S="${WORKDIR}/${PN}-${PV}"

SRC_URI[md5sum] = "b19a6cabbf38ca23df6a8bb4431b110d"
SRC_URI[sha256sum] = "bd39406ef6b0ca9b1c26840573dcfce7ca68aa2c16243531ce6e157db48a3196"

PACKAGE_FP_TYPE = "hardfp"
