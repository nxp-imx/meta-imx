# Copyright (C) 2015 Freescale Semiconductor

require imx-gpu-viv-kernel.inc
          
SRC_URI[md5sum] = "addcaa6fde8f4a10cc1fe0e127ef5271"
SRC_URI[sha256sum] = "fcea5c2ba1010b6707f22ca5585d7b4baca2791066e81a37a618d06971eda40b"

S = "${WORKDIR}/${PN}-${PV}"
