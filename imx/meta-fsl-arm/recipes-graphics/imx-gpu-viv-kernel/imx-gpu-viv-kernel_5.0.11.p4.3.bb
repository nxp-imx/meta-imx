# Copyright (C) 2015 Freescale Semiconductor

require imx-gpu-viv-kernel.inc
          
SRC_URI[md5sum] = "14b9d5673caa49c84eb9126c33bcfce1"
SRC_URI[sha256sum] = "359223c1ef3c4fe81223985ea5cb5db38647358b4d62cfba5672b2ed40717e52"

S = "${WORKDIR}/${PN}-${PV}"
