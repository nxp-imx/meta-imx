# Copyright (C) 2013 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-graphics/gpu-viv-bin-mx6q/gpu-viv-bin-mx6q.inc

SRC_URI[md5sum] = "617fad6c4c629a82ffe7dc4533757920"
SRC_URI[sha256sum] = "eb9cd673e270b32ed4df9425101346d01d57df27d2ce26f74ff4fa9efdb26522"

PACKAGE_FP_TYPE = "softfp"

