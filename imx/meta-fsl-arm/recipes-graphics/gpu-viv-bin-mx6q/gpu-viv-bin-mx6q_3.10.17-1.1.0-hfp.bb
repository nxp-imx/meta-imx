# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require gpu-viv-bin-mx6q.inc

SRC_URI[md5sum] = "f191a9dd715c69cf83a8884c2a3a4bee"
SRC_URI[sha256sum] = "ff868d0637627d6de771ca25ac49ae17a7ee10fe227f65faac0868a9c5b97591"

PACKAGE_FP_TYPE = "hardfp"
