# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require gpu-viv-bin-mx6q.inc

S="${WORKDIR}/${PN}-3.10.53-1.1.0-hfp"

SRC_URI[md5sum] = "bc7bc2b07034ab2765f5699110e29231"
SRC_URI[sha256sum] = "e091ac119332264fd9df55a4c0b0a055dfbb2f253f1ec4bd5edde1530a43be0c"

PACKAGE_FP_TYPE = "hardfp"
