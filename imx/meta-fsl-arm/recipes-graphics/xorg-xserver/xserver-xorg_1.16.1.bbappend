
# Fix mutli-touch issue: can not close the windows by touch
SRC_URI += "file://0001-Fix-subwindow-in-Xi-emulated-events.patch \
           "

