# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv.inc

S="${WORKDIR}/${PN}-${PV}"

SRC_URI[md5sum] = "ce83bcbafb2c9e385b3bb283354ab8e8"
SRC_URI[sha256sum] = "2310bf876318793dce39f468f1b3df26966e07194b90ed1ed67a9b321925993c"

PACKAGE_FP_TYPE = "hardfp"
