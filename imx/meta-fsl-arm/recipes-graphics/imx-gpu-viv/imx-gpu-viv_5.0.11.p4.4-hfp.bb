# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv.inc

S="${WORKDIR}/${PN}-${PV}"

SRC_URI[md5sum] = "23ece66188331a8264273a003686c7dc"
SRC_URI[sha256sum] = "2d238ac8b918a2dcf3a406ed589a5b6cf4974dbdd692bce5718af45f899d5889"

PACKAGE_FP_TYPE = "hardfp"
