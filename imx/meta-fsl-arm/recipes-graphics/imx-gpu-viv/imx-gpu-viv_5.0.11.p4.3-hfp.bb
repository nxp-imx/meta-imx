# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv.inc

S="${WORKDIR}/${PN}-${PV}"

SRC_URI[md5sum] = "69cdea53c850a93d62cf8f49e8ec8988"
SRC_URI[sha256sum] = "c6ed142cbdcd5dd82286310696b6426045ae1597fe6d3c622357dbba79588305"

PACKAGE_FP_TYPE = "hardfp"
