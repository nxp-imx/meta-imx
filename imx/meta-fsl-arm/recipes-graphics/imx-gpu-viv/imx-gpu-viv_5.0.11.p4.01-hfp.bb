# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv.inc

S="${WORKDIR}/${PN}-${PV}"

SRC_URI[md5sum] = "5f17f19b2d6309e98bbd5a8d15f6ebc8"
SRC_URI[sha256sum] = "3a45088ac791cdc7a25835d9a4a3309eea3064024436cf2cddec0eef60574883"

PACKAGE_FP_TYPE = "hardfp"
