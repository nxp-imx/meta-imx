# Copyright (C) 2013, 2014 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-gpu-viv.inc

S="${WORKDIR}/${PN}-${PV}"

SRC_URI[md5sum] = "3249f46b57fa67e51a529c89f5c875c2"
SRC_URI[sha256sum] = "acd0121a529c5fe7a41ba84962f1c1b43ffd16d145c2c9fca3d7bb81eadc597e"

PACKAGE_FP_TYPE = "hardfp"
