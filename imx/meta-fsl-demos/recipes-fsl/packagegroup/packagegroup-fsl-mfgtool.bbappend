RDEPENDS_${PN}-extfs += " \
    e2fsprogs \
    e2fsprogs-e2fsck \
    f2fs-tools \
"
