export GYP_DEFINES="${ARMFPABI} release_extra_cflags='-Wno-error -Wno-error=deprecated-declarations -Wno-error=unused-local-typedefs' sysroot=''"


