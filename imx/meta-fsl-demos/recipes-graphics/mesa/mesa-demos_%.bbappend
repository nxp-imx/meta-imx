

PACKAGECONFIG_remove_mx6sl = "gles1 gles2"

