
require arm-compute-library.inc

SRCREV = "514be65ad8d3340f53fd9591035352ed285811ba"
