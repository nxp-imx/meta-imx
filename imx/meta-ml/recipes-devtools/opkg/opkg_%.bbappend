RDEPENDS_${PN} += " opkg-feed-config"
