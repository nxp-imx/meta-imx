require python-unittest-xml-reporting.inc
inherit pypi setuptools3
