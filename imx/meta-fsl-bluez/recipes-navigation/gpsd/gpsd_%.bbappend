PACKAGECONFIG[bluez] = "bluez='true',bluez='false',virtual/bluez"