DEPENDS = "glib-2.0 dbus virtual/bluez dbus-glib libxslt-native libxslt"