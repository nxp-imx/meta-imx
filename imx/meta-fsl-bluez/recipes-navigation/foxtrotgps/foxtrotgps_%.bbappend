DEPENDS = "curl gtk+ libglade sqlite3 libexif gpsd virtual/bluez intltool-native"