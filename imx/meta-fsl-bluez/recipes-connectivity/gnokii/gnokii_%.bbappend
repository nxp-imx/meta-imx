PACKAGECONFIG[bluez] = "--enable-bluetooth,--disable-bluetooth,virtual/bluez"