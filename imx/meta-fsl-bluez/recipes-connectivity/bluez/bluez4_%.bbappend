
PROVIDES = "virtual/bluez"
RPROVIDES_${PN} = "VIRTUAL-RUNTIME_virtual/bluez"
