RCONFLICTS_${PN} = "bluez5"