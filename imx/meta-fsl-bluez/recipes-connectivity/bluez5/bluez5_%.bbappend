
PROVIDES += " virtual/bluez"