
# obexd was integrated into bluez5
RCONFLICTS_${PN} = "bluez5"
