DEPENDS = "gtk+ virtual/bluez dbus-glib imagemagick openobex"
