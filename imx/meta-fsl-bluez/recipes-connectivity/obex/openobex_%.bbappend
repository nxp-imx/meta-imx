
DEPENDS = "virtual/libusb0 virtual/bluez"
