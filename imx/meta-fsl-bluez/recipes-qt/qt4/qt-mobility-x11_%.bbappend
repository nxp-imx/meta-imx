
PACKAGECONFIG[bluetooth] = ",,virtual/bluez"