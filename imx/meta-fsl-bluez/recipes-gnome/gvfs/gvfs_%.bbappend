
PACKAGECONFIG[obexftp] = "--enable-obexftp, --disable-obexftp, virtual/bluez expat"
