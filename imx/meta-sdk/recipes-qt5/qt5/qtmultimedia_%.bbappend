
PACKAGECONFIG_append = " gstreamer openal"
