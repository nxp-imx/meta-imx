# Copyright 2017-2019 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-m4-demos-2.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=80c0478f4339af024519b3723023fe28"

SRC_URI[imx8qx.md5sum] = "d31f8bacd5a4bda807ce51c3b6888307"
SRC_URI[imx8qx.sha256sum] = "186ef72fde396c6e7234fb844f6d713f266c5699aa1da5a557f32e021f050955"

COMPATIBLE_MACHINE = "(mx8qxp)"
