# Copyright 2019 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-m4-demos-2.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fb0303e4ee8b0e71c094171e2272bd44" 

SRC_URI[imx8mm.md5sum] = "47878b874aaf7be0166dca4b72152b88"
SRC_URI[imx8mm.sha256sum] = "e768ced9cf15dfd1651d9725cdbaa7a18eac97248cd197cc96f8fb7d94d106fe"

COMPATIBLE_MACHINE = "(mx8mm)"
