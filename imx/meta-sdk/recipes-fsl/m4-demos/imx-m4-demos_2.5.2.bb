# Copyright 2017-2019 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-m4-demos-2.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=80c0478f4339af024519b3723023fe28" 

SRC_URI[imx8qm.md5sum] = "65304a75c1ef275693bc5789c9b3c3bc"
SRC_URI[imx8qm.sha256sum] = "9be6c8b3d8e8fea6bfa48e07fc24ce3c647b5c69959c0cedf9625ab82172c964"

SRC_URI[imx8qx.md5sum] = "0a27c710ad5302334f1b7119e6a2ac03"
SRC_URI[imx8qx.sha256sum] = "5b9bf410e3a64510e97940f892c514928ad4bee73fcd695a2aabf356824cb26f"

COMPATIBLE_MACHINE = "(mx8qm|mx8qxp)"
