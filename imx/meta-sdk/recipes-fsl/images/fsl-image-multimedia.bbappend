RDEPENDS_${PN}_remove_mx6ul = "clutter-1.0-examples"

