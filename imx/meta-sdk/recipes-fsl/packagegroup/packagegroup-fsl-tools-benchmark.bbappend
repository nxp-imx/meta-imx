RDEPENDS_${PN}_remove = "tiobench"

# Replace iperf with iperf3
RDEPENDS_${PN}_remove = "iperf"
RDEPENDS_${PN}_append = " iperf3"
