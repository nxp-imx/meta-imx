DFB_TOOLS_INSTALL = ""
DFB_TOOLS_INSTALL_mx6q = "libvivante-dfb-mx6"
DFB_TOOLS_INSTALL_mx6dl = "libvivante-dfb-mx6"
DFB_TOOLS_INSTALL_mx6sx = "libvivante-dfb-mx6"
DFB_TOOLS_INSTALL_mx6sl = "libvivante-dfb-mx6"

RDEPENDS_${PN} += " \
    ${DFB_TOOLS_INSTALL} \
"

