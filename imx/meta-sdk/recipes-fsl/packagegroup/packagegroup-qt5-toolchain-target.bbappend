
RDEPENDS_${PN}_remove_mx6 = "${USE_RUBY}"
RDEPENDS_${PN}_remove_mx6ul = "${USE_RUBY}"
RDEPENDS_${PN}_remove_mx7 = "${USE_RUBY}"


RDEPENDS_${PN}_append = " \
    qtdeclarative-tools \
    qtmultimedia-examples \
"
