#Provide our own rc.local file
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
