COMPATIBLE_HOST_imxgpu = "aarch64-poky-linux"
