
COMPATIBLE_MACHINE = "(mx8)"
