RDEPENDS_${PN}-test = "python3-core"
