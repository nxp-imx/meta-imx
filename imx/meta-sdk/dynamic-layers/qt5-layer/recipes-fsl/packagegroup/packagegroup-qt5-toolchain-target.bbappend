
RDEPENDS_${PN}_remove = "qtquick1-dev \
    qtquick1-mkspecs \
    qtquick1-plugins \
    qtquick1-qmlplugins \
    qttranslations-qtquick1 \
    qtwebkit-dev \
    qtwebkit-mkspecs \
    qtwebkit-qmlplugins \
"

RDEPENDS_${PN}_append = " \
    qtdeclarative-tools \
"
