# Install qt5 packages
IMAGE_INSTALL += " \
    packagegroup-qt5-imx \
"
