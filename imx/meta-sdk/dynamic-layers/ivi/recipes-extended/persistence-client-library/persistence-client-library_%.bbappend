# Temp fix build with GCC 9
CPPFLAGS += "-Wno-error=stringop-truncation"
