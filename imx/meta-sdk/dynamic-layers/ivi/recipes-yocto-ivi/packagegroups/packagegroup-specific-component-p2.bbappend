RDEPENDS_${PN}_remove = "vsomeip"
