
RDEPENDS_${PN}_remove = "audiomanagerplugins"
