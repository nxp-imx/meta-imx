
RDEPENDS_${PN}_append = " weston-init"
