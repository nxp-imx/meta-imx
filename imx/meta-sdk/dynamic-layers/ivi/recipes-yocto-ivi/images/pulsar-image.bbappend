IMAGE_FEATURES += "nfs-server ssh-server-openssh tools-debug"
IMAGE_INSTALL_append = " packagegroup-fsl-tools-testapps packagegroup-fsl-tools-gpu"
