GNOME_COMPRESS_TYPE = "gz"

SRC_URI[archive.md5sum] = "d0f5ab4d8a57c8da7de29fce300cfad8"
SRC_URI[archive.sha256sum] = "0f6e485ce26cdee1f3e24c994815628677d20b1946fbe7997a38bf83c3133862"

