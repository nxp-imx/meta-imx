# Override the SRCREV in meta-qt5 till we upstream
LIC_FILES_CHKSUM = "file://main.cpp;md5=b09598d736187eeb9738630f8ec7b663"
SRC_URI = "git://code.qt.io/qt-labs/qt5-everywhere-demo.git;procotol=https"
SRCREV = "6178748a6ea34df40a8e3c9ce67137e33383bb0e"
