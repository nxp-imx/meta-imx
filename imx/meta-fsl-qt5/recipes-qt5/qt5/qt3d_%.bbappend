SRC_URI = "git://code.qt.io/qt/qt3d.git;protocol=http;branch=dev"
