SRC_URI = "git://code.qt.io/qt/qtsystems.git;protocol=http;branch=dev"
DEPENDS_remove = "bluez4"
DEPENDS_append_mx6 = " virtual/bluez"
