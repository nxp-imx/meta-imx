# Change branch to stable to 5.3 branch
#
# This is backport from dizzy branch
# As the new stable branch is 5.4 and the SRCREV 
#  aa651c7 is not yet included in that branch; reference to
# https://github.com/meta-qt5/meta-qt5/commit/0732e184acef5e0200f46d7f95702774e5de1904

QT_MODULE_BRANCH = "5.3"
