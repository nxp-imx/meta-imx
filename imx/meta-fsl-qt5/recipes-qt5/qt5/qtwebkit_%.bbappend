FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-qtwebkit2-Patch-the-proposed-fix-in-the-current-QTWe.patch"
