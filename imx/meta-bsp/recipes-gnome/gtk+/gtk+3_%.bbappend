
RDEPENDS_${PN}-demo_remove = "libgl"
