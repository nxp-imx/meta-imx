require imx-gpu-g2d.inc

SRC_URI[md5sum] = "1add0f7817471a2eb36d9c7c4f9302cf"
SRC_URI[sha256sum] = "064e44b591dd8f470d8504ed1b39ad472108caa8637ee58ede01b812ad2a7747"
