require imx-gpu-g2d.inc

SRC_URI[md5sum] = "931474831082bba221b241297d74b744"
SRC_URI[sha256sum] = "c70f0bccf6cf8d1252edf88362233fbb0cb8e5befe6b56b7f950b3db174274d6"

COMPATIBLE_MACHINE = "(mx8mm)"