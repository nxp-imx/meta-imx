require imx-gpu-g2d.inc

SRC_URI[md5sum] = "cb0cde64e45ca26974990a726f07d9ab"
SRC_URI[sha256sum] = "b9cdac1a73d4819acecbfb2a070f687bb15e522ce58335956cdf321df744d6f2"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
