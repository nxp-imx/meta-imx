require imx-gpu-g2d.inc

SRC_URI[md5sum] = "a9a25f7b916b6601af05365e22affa9e"
SRC_URI[sha256sum] = "d9c6f32782a1fd08a51161014a2507c715133e6c9df5d92772c9f48cc4256aa1"
