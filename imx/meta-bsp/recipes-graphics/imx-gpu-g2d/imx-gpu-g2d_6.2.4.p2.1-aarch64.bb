require imx-gpu-g2d.inc

SRC_URI[md5sum] = "1e1481a382bc8ac82ad0ebe2da8f07dd"
SRC_URI[sha256sum] = "4974f0d617bd22565597edc41c24e1345e7d968258511af1b1a7c9b5f7daa740"
