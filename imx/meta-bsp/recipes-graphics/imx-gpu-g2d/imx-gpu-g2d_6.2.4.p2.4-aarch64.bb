require imx-gpu-g2d.inc

SRC_URI[md5sum] = "c1568cf28b6148dfc2a98fc45b3ede7e"
SRC_URI[sha256sum] = "297134cdf9e1fa9bfb78b3250da151dd2bcddf3cdc417a09e222267caf11082f"
