require imx-gpu-g2d.inc

SRC_URI[md5sum] = "a2f0c834607ffd8a003db1d005465344"
SRC_URI[sha256sum] = "772ee0580004e243eec5e7b4d482a0f8d992603a85fbe5c53b541f4c0080f51b"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
