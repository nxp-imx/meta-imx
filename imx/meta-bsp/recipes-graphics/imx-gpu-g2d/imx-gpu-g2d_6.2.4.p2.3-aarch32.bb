require imx-gpu-g2d.inc

SRC_URI[md5sum] = "3122e2274cc00f62ff4e6deb273fa1cf"
SRC_URI[sha256sum] = "f44b688895dfb21af66cfc32f116eec097f4bf7012138ccc09334e637f110539"
