require imx-gpu-g2d.inc

SRC_URI[md5sum] = "22779c5b1131de3b90d11a95e96f6962"
SRC_URI[sha256sum] = "35cbb54d6a9ccdb50a8e14c9cb88ab44c4b16cf4be62e6353ec0abd570b8d8fe"

COMPATIBLE_MACHINE = "(mx8mm)"