require imx-gpu-g2d.inc

SRC_URI[md5sum] = "f8fc3d0429f503290a6fe46cc781d84a"
SRC_URI[sha256sum] = "ec8a512773b7ca4aef2f65e132b0c313f598601ffe47bab8d1a89c484f0ac3e0"
