require recipes-graphics/xorg-driver/xf86-video-imx-vivante.inc

SRCREV = "8ea614949fdefd4ab655d3944fc32d62cb48c3be" 
