require recipes-graphics/xorg-driver/xf86-video-imx-vivante.inc

SRCREV = "946e8603ed9a52f36d305405dbb2ab8ff90943d0" 
