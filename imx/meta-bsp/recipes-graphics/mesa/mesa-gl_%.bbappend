COMPATIBLE_MACHINE_mx8  = "(-)"
