require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "ffdf0ad5157fa384cb36924e814d3d4a"
SRC_URI[sha256sum] = "bca68105233c6c1eace6ac52053cb0015b4138b618bc5aabf9785eb246d031a7"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
