require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "1f600ef86e3e18db54b41b6a571fb4c8"
SRC_URI[sha256sum] = "b072886fd560e1b2accd7e6d049bdc26563a711ccaedde75a0b29b613b2632f5"

COMPATIBLE_MACHINE = "(mx8)"
