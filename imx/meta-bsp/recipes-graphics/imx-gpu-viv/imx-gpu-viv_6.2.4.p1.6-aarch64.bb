require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "34b9b045b8cefe6dd0e1cde944ad9f27"
SRC_URI[sha256sum] = "d349ad1e6949397ed8cb2fa22dec0fa67bab496fe0bfaee9da50bcc68d84a0ad"

COMPATIBLE_MACHINE = "(mx8)"
