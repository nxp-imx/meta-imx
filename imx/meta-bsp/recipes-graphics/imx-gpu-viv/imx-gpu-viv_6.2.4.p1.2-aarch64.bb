require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "5e8105664e32082fd1156605e6125b01"
SRC_URI[sha256sum] = "42c0e6c413f0d662282adca96ce09469881aaf8ca22f050028d93e4760a0358c"

COMPATIBLE_MACHINE = "(mx8)"
