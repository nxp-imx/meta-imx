require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "0f03295ee225ffd1259d66c97920e561"
SRC_URI[sha256sum] = "1badea87b902eb483ccbc1479161db187f54d872092e5b5e3768f617e6947552"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
