require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=72c0f70181bb6e83eee6aab8de12a9f3" 

SRC_URI[md5sum] = "f6bfdb74e4cec15706a0f2cb5b9a9a7e"
SRC_URI[sha256sum] = "ae4623a8a2ea5d07b54e408dfda79a9caf6921147dd9f00daba4b7455ef4c876"

COMPATIBLE_MACHINE = "(mx8)"
