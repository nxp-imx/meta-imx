require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "3a1213869a6611242cf77f87bc70b54f"
SRC_URI[sha256sum] = "f00477f5616265e4c947975b8df1811c8c7a93741a5577517f94c80a99bb812f"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
