require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fb0303e4ee8b0e71c094171e2272bd44"

SRC_URI[md5sum] = "49cff289e800718c6a450220962c41e6"
SRC_URI[sha256sum] = "01431c9d6cc7be8aec8f0021aba5b6a6fbc9c0d0f408dd64fc8bce7b64bc2f2d"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
