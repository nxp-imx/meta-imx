require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "69373412fad7d22398712c1ce12ccea5"
SRC_URI[sha256sum] = "b0167b18a87c0bf5d0bc28d59b292a7ba003bc4429b58fcad3f69654f435acf7"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
