require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "9f391df90a3202a1d0ef40b929642bc0"
SRC_URI[sha256sum] = "aac8cc608290e71a868d53a7f2c19ef61fed566b605624b22cf51d3b7f3af56b"

COMPATIBLE_MACHINE = "(mx8)"
