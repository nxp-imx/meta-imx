require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fb0303e4ee8b0e71c094171e2272bd44"

SRC_URI[md5sum] = "fdf89e07e5ea9b8d544471af7810b105"
SRC_URI[sha256sum] = "0b0bb0abcf7bfeb1261fc4a08de4da366692330837de41814901d1dde4d7f60d"

COMPATIBLE_MACHINE = "(mx8)"
