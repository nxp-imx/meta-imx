require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "90ed0116d9909a3bb78d2acbfd5fe916"
SRC_URI[sha256sum] = "1943e0260f738b7cbe4cbb65a50108459b99cdedfb4d8f982becb1bca20b63c6"

COMPATIBLE_MACHINE = "(mx8)"
