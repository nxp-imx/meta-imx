require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "103841f08d4b86ba9c0c8aa88a834351"
SRC_URI[sha256sum] = "1aef885e1f9932a93cc7b8b42981046ad3fed2023b27a8d9e0f4d3598c40c3ea"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
