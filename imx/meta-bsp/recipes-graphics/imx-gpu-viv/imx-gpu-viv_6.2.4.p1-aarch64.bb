require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "b5f628ebedfc56acb75f2e5c775674df"
SRC_URI[sha256sum] = "6104f5eda6fe3e4e60a052c36c939536624641c95555330c5285395e4e62a46b"

COMPATIBLE_MACHINE = "(mx8)"
