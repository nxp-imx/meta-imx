require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "3d73543b95aea79ca4a8a921e464ff93"
SRC_URI[sha256sum] = "87fb33e0cd2c31d7f3d0e23c1c20c21d67032f8b7feb4cde21fb2ab9a6d6dc49"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
