require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "0b9cc27e2b4b3a36d7aefa0e5a60f4c6"
SRC_URI[sha256sum] = "0b44842947c74d1c409a0a7b1553eea39e16e3968559df6a7004e976a31d2ad2"

COMPATIBLE_MACHINE = "(mx8)"
