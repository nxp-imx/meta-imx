require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=72c0f70181bb6e83eee6aab8de12a9f3" 

SRC_URI[md5sum] = "54d8482120aa28ef5bbf1f7ff6bf24b7"
SRC_URI[sha256sum] = "e10afde0072f7934e060ad7bb6b65c670f8413e6d2101940040deba288694c5f"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
