require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "9fbb0f5f03e769d580c45dc7835ec359"
SRC_URI[sha256sum] = "d939de09e6f3492e5c2cbe0d685825a35a5c5fe06cb63ebfa60d296bf87f2ec7"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
