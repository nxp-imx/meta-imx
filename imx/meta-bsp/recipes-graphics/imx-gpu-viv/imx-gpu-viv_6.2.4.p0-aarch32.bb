require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "43e01180b0c7854f636a60e54e82e085"
SRC_URI[sha256sum] = "a96a92472a93973775284044907e42bf3aceb353793521a935b65c538db314ae"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
