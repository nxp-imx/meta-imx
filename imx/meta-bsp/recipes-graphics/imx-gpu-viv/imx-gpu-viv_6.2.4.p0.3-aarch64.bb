require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "24e080d1d2c2eca44d8e91063fadf6c5"
SRC_URI[sha256sum] = "39cb5d8eabfc3d2280448a7cb2ff388d7fc6e78e8f19a9a8930a3d96069d81fe"

COMPATIBLE_MACHINE = "(mx8)"
