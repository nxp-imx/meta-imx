require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "c21583065f86fb668ca0ab94f6fa9495"
SRC_URI[sha256sum] = "87ad487b2a65fd2b00af769bc994acadf2030790424da680249c74beddd596bc"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
