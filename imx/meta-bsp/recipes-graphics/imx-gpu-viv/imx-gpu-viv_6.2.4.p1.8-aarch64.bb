require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "a238f04d71f62f64af4236a36bf8b468"
SRC_URI[sha256sum] = "cf16636ab3e24ed1b86385faae9fa292a659fd0a88fbdf99f24880c04ba068fa"

COMPATIBLE_MACHINE = "(mx8)"
