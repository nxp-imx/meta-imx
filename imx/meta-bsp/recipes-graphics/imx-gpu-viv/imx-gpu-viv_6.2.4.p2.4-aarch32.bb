require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "d5851d995ebddd81306d204ed7840605"
SRC_URI[sha256sum] = "dbc1d99328dfcd98ecaeec3614d5656080adb515899949bad5c66a79e5c16e58"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
