require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fb0303e4ee8b0e71c094171e2272bd44"

SRC_URI[md5sum] = "a5568f8784ef990c7ac14c153f313272"
SRC_URI[sha256sum] = "03e2258a3ec7fb501fa937c4813f768cfa5f844cb5601bcd6c4956016f293a98"

COMPATIBLE_MACHINE = "(mx8)"
