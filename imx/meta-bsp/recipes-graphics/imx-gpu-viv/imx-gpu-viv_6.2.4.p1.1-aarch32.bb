require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "f058e47181fcdc9d08651a7d4d59e898"
SRC_URI[sha256sum] = "40e211ae6865f311ec9e08533d7e47e00e5c955ac9b000dfdf54a68f7e31f433"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
