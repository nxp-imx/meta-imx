require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "29af46fd737e30667a62404b6eee7a5b"
SRC_URI[sha256sum] = "fb784422621d97a4ac2c7e87cd9c6be2e92dfc4d89011c4b1ec6c8ae97c8c6db"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
