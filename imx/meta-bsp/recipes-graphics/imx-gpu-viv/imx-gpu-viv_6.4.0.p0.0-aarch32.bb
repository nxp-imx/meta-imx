require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fb0303e4ee8b0e71c094171e2272bd44"

SRC_URI[md5sum] = "b0a187f45eb29990b71186f8a93499ca"
SRC_URI[sha256sum] = "3e4fbbd083fb1730cddae2384b7ac715d9cc368554696a860f16f81beb5b805b"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
