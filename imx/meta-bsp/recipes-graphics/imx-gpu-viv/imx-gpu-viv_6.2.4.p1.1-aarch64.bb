require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "38dbb46d9362add41406e3147bd7a906"
SRC_URI[sha256sum] = "b8f88e7815da6ba916055ff50ce81082b416d2d878261d6cced7a3482181b560"

COMPATIBLE_MACHINE = "(mx8)"
