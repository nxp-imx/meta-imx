require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "d0d3798ba5215c672491470befeb9b88"
SRC_URI[sha256sum] = "72c9a3270f7d2845dbf735aff7880cf6d31974c0c635c319e6c010e6431d0219"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
