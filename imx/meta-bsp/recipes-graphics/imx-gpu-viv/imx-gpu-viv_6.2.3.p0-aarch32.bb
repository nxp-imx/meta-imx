require imx-gpu-viv.inc

SRC_URI[md5sum] = "8f1feb028516de37aea38e02b045c633"
SRC_URI[sha256sum] = "2801775a35417d28a1702870bebb557abaa4f8058aa6b5e7b4c537e6a35b8d8c"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
