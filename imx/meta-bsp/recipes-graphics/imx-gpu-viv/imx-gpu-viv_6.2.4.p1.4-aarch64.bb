require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "bec528b917fdf710e85ae77d201a8567"
SRC_URI[sha256sum] = "e1f8b1a835739846a8e6b650a65dad1eb097047cba774a13426d2a0b550cb1fd"

COMPATIBLE_MACHINE = "(mx8)"
