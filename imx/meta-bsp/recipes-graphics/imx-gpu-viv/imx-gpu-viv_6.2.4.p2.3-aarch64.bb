require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "edfce817372f812c6a6969826033dc8e"
SRC_URI[sha256sum] = "3fddc500f51ffd4fe69e81234a92baab197dd5ad1cdf1c4e0acf73366078de96"

COMPATIBLE_MACHINE = "(mx8)"
