require imx-gpu-viv-v6.inc

SRC_URI[md5sum] = "fe0129a1a99763697b67bbd29e32ed8a"
SRC_URI[sha256sum] = "fec3da52c2fe044cb357626122647a835f0372413aca50303353a51f16922af6"

COMPATIBLE_MACHINE = "(mx8)"
