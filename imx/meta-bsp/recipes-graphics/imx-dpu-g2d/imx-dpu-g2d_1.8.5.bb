require recipes-graphics/imx-dpu-g2d/imx-dpu-g2d_1.7.0.bb

LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"

SRC_URI[md5sum] = "6fd41a6a6c7e416f2af4a398aa20d0ab"
SRC_URI[sha256sum] = "8e2c8b20e013bc56cea758b3a11563b35cd3191720e760bbfebd491802d1ceae"
