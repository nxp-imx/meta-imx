require recipes-graphics/imx-dpu-g2d/imx-dpu-g2d_1.7.0.bb

LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"

SRC_URI[md5sum] = "76afa60b10e420d141b7d877192b25a7"
SRC_URI[sha256sum] = "f195028c9ede40c01e15f9ef9c78762341f51fc059c292f802b880ca210c5f01"
