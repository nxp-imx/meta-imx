require recipes-graphics/imx-dpu-g2d/imx-dpu-g2d_1.4.8.bb

LIC_FILES_CHKSUM = "file://COPYING;md5=fb0303e4ee8b0e71c094171e2272bd44"

SRC_URI[md5sum] = "411f6dd52fa263812fd99962c690ab79"
SRC_URI[sha256sum] = "4f6dad92b57123aa3d5778f110e62679aab9332f363da3e27e0501682e02c6c0"
