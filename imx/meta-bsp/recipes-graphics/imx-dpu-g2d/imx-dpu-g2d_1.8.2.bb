require recipes-graphics/imx-dpu-g2d/imx-dpu-g2d_1.4.8.bb

LIC_FILES_CHKSUM = "file://COPYING;md5=fb0303e4ee8b0e71c094171e2272bd44" 

SRC_URI[md5sum] = "355a4fcf5e63fc5ab0a7713eae15ef2a"
SRC_URI[sha256sum] = "38225e34b19c607bfb67c3ec6e27eaaf45be431e6896fd39e7be628acf4f6255"
