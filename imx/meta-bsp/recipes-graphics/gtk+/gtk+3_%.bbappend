SRC_URI_remove = "file://0004-configure.ac-Fix-wayland-protocols-path.patch"

EXTRA_OECONF_remove = "WAYLAND_PROTOCOLS_SYSROOT_DIR=${RECIPE_SYSROOT}"
