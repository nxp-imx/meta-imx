# The line is in the 4.0.0 recipe but removed for some reason in
# the 4.1.0 recipe. It seems to still be needed.
FILES_${PN}-dev += "${libdir}/cmake/"
