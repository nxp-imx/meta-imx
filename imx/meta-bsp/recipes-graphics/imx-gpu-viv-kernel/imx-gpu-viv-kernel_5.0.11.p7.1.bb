# Copyright (C) 2015 Freescale Semiconductor

require imx-gpu-viv-kernel.inc
          
SRC_URI[md5sum] = "f142f8ac1462571e44f6aabadeeb86c7"
SRC_URI[sha256sum] = "894b616c904bcfcc4e4421e836ecce477cf6b72e45425619e8a3e64723d64c48"

S="${WORKDIR}/${PN}-${PV}"
