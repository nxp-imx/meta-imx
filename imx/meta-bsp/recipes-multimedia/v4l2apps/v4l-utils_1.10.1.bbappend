DEPENDS_append = " virtual/libgl"

