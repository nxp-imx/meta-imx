# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=d4f548f93b5fe0ee2bc86758c344412d"

SRC_URI[md5sum] = "732c49fccf85d9513dd780e853e9cc0b"
SRC_URI[sha256sum] = "c357b0563de2292e729535483f3d2468381f4b2c06fc4a2d10add126eafd6454"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7|mx8)"
