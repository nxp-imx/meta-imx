# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=88595f92466edd79be7f4f9547ffa0ef"

SRC_URI[md5sum] = "730f80e8eb2eee9deaacf616e4f6b3a9"
SRC_URI[sha256sum] = "c60f86c9ac09c9ba861279dac6a619b73dbd7e136071a7caf4e9eb740937c7dc"

COMPATIBLE_MACHINE = "(mx6|mx6ul|mx6sll|mx7|mx8)"
