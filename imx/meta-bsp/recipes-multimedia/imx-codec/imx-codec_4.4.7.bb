# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fb0303e4ee8b0e71c094171e2272bd44"

SRC_URI[md5sum] = "7a37e711fb604d28b06b428e43764d71"
SRC_URI[sha256sum] = "44144de2604ca4b50a767846acfaf6180f73127101af500606c0db758d9fc933"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
