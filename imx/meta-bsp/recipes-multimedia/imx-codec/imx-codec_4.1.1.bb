# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=102094e9e695888c6a9f9fda9004165d"

SRC_URI[md5sum] = "99e2ac17d5685c13cb4912858f6ca4ad"
SRC_URI[sha256sum] = "b6fdebbbaaa6ae36aa0465a903f958225bfaabe8d3048cbff80a3c2a9de75e9b"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7|mx8)"
