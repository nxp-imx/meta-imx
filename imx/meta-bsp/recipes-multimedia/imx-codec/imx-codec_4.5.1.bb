# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3"

SRC_URI[md5sum] = "b882f2f184db186802db3bbb54f05bc4"
SRC_URI[sha256sum] = "ea4ba6ec43059ded3fe9af509c226b7da918423d84354b627d95a798eb4759e5"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
