# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=72c0f70181bb6e83eee6aab8de12a9f3"

SRC_URI[md5sum] = "05181ffe57aec33610401e8cbca0016c"
SRC_URI[sha256sum] = "c8d1c9e5bfd83092c1c3a8e9f134d69d5ec24520cf446bbdce14786a4676db9e"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
