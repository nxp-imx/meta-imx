# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3"

SRC_URI[md5sum] = "239ec0101a10e2d057ad88399bebc242"
SRC_URI[sha256sum] = "5bce1b6288cdc34d52ea642e7f5d62643c424e72177cc67c55f9e20948c88fbd"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
