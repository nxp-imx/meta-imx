# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

SRC_URI[md5sum] = "5073ec1846e62ea3c5aaae6ff36fcda7"
SRC_URI[sha256sum] = "be238a44bce813ccf5617b680c658949e21012c6a7091a104d85e45db1995131"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx6sll|mx7|mx8)"
