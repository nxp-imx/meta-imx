# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=6b552f505eedab4a11ab538cf3db743a"

SRC_URI[md5sum] = "3f2c847445194775df1fef851530ad87"
SRC_URI[sha256sum] = "b50f88182d2d047d8fec56abb928d82361ae2566d3a8e32f7edd6fa79af48b71"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
