# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5ab1a30d0cd181e3408077727ea5a2db"

SRC_URI[md5sum] = "0259dad799dc5797038dfb5002e82f75"
SRC_URI[sha256sum] = "cf19378b5bf2a2780baae44073f74f6923a30633624b3fc8840df5aaf2ecd110"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
