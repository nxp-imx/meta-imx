# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fb0303e4ee8b0e71c094171e2272bd44"

SRC_URI[md5sum] = "c76ff6320e7275ab5730077e41eb02e5"
SRC_URI[sha256sum] = "bb0984c03db2ea61dc7cb45b05efb0fefb7802932ea50a898a50ceeb13d84cac"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
