# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=102094e9e695888c6a9f9fda9004165d"

SRC_URI[md5sum] = "10981a700b4babe7adf7ff3e4d8c3012"
SRC_URI[sha256sum] = "a2273ab2a805a596fecad77d3d0d86b4e2389d55002384d90359677dc1a146c6"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7|mx8)"
