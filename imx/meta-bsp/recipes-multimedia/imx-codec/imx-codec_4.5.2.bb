# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3" 

SRC_URI[md5sum] = "3dd71d9a8fa886a6a03c76cd111d23b6"
SRC_URI[sha256sum] = "1dad646403e5cf7dcbd59f8fd535da98af5dd0d0859bdb64ce9c440da3dc6d7a"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
