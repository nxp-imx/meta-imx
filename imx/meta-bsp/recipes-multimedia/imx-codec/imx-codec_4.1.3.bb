# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=102094e9e695888c6a9f9fda9004165d"

SRC_URI[md5sum] = "54df656a061d62a0bdf41352e18b3342"
SRC_URI[sha256sum] = "ccbe3eed748bddb3e863e4ecc7a5c0085e1f32faae6b5b03cdd7be842f5e7ff1"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7|mx8)"
