# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3"

SRC_URI[md5sum] = "2ad4f54bc42a4e75a35ad1a154523a92"
SRC_URI[sha256sum] = "d2e759bb4501f286d03175ea2ff8486e8ff61b73d3a2f8c451c5a4f7b710c381"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
