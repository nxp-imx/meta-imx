# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=102094e9e695888c6a9f9fda9004165d"

SRC_URI[md5sum] = "595eb6b5f16b631601149d3bd2aa1203"
SRC_URI[sha256sum] = "fa1f23c12a9592b58e73b543fe67f4060fa9c87a3ff5b3dcafcab29f5f5f99c8"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7|mx8)"
