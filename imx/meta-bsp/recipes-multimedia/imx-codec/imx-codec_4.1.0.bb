# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=102094e9e695888c6a9f9fda9004165d"

SRC_URI[md5sum] = "82ac41c059fdc1952efb9aef7d99c1c7"
SRC_URI[sha256sum] = "5ed4a1f709a04fd3f2e3e2e9bb25c236eab2065d4d1de0d33d3ff6c0518748d5"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7|mx8)"
