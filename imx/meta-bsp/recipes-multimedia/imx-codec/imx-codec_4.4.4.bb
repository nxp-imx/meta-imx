# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-codec.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5ab1a30d0cd181e3408077727ea5a2db"

SRC_URI[md5sum] = "7f98cf6a11fb93bc2537abd9c3805d42"
SRC_URI[sha256sum] = "03a3b9007fd3d3e15fe251fd238eeadbd12d05e61bdc162d3ef425435c10b38d"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
