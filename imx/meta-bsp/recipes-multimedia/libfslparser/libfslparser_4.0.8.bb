# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslparser/libfslparser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=01ba08a2b77c3a0a9d0ab5d4d83fed64"

SRC_URI[md5sum] = "d196f59c7fd4833ff1792861a40ae244"
SRC_URI[sha256sum] = "d4252a47ed4e1f6f48fc00a04add5c6040ad1c67e23f8e7e3b7a85ec3636e4f0"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7)"
