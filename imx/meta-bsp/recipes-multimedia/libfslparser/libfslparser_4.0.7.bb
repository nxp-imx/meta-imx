# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslparser/libfslparser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=01ba08a2b77c3a0a9d0ab5d4d83fed64"

SRC_URI[md5sum] = "040bbe87100e672b3468222b0a3efe9f"
SRC_URI[sha256sum] = "fc290aa452d044c9bd8cd61840a04e708b855b29bf34e1e4ff52881f39f1a5c4"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7)"
