# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslparser/libfslparser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=01ba08a2b77c3a0a9d0ab5d4d83fed64"

SRC_URI[md5sum] = "033209c9b91c6876187259686b7a449b"
SRC_URI[sha256sum] = "e7b28c398d320af195dc15273a3cebe6b381893359118093fac75ab87cf1afb1"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7)"
