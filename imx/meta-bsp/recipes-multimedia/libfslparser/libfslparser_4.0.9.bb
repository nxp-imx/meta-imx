# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslparser/libfslparser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=3880bb9c943b135a30fad5e8aabd3ee9"

SRC_URI[md5sum] = "71e8b1694ae4e01f0a237e01c5c673ec"
SRC_URI[sha256sum] = "e17ab4d0743263660c72b07577ce6712096895e0157ee6ae8e32fbe71aea068a"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7|mx6ul)"
