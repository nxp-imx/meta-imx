EXTRA_OECONF_append = " --disable-introspection "
