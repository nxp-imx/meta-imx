FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = " file://0001-imx-gst1.0-plugin-Disable-PXP-G2D-temporarily-as-a-w.patch"
