COMPATIBLE_MACHINE = "(mx6|mx7|mx6ul)"
