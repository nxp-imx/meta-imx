COMPATIBLE_MACHINE = "(mx6dl|mx6q|mx6sl|mx6sll|mx6sx|mx6ul|mx6ull|mx7d)"

