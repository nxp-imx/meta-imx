# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=08fd295cce89b0a9c74b9b83ed74f671"

SRC_URI[md5sum] = "2b7fa9ce1f64945b97227498cafa4950"
SRC_URI[sha256sum] = "ff29edf5c4113209d3cb4de5079aac79a752bf9656b7533f9b434cfbb139a52d"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
