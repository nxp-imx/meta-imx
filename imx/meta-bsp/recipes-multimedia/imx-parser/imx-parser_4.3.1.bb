# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=08fd295cce89b0a9c74b9b83ed74f671"

SRC_URI[md5sum] = "81b346ac0709d559cd101c94ce7e8ed7"
SRC_URI[sha256sum] = "592a59bb5ee93968c5ff6f396f86f671b32e74a3add910f44d0c7378c15d635c"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
