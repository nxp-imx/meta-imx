# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

SRC_URI[md5sum] = "8392d566e7a6e7e007a00fb2ac5b98f6"
SRC_URI[sha256sum] = "34e52b56aeebd675787d79f0c53d10d2466265e9f7a97c8ac172f2320cc4f180"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx6sll|mx7|mx8)"
