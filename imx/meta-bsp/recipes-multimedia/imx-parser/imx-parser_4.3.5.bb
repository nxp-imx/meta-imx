# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=08fd295cce89b0a9c74b9b83ed74f671"

SRC_URI[md5sum] = "182ab329533a5030e01dc9443aad1f45"
SRC_URI[sha256sum] = "e4fbf5128e6193733af350b3259d3d8b1cdbd577bd2133e07c7130c0543542ae"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
