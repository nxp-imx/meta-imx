# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3" 

SRC_URI[md5sum] = "99cfc6cd62f6e5b223f14887b99b1b28"
SRC_URI[sha256sum] = "f261cf6246e8cce2f6711e7c76f3723a914444a4558bf4dc34fa822d17e713d7"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
