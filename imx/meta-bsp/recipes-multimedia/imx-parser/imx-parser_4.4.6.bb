# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=80c0478f4339af024519b3723023fe28"

SRC_URI[md5sum] = "a4f9a047d2ec104879390f5a82e7f165"
SRC_URI[sha256sum] = "440f29436f2ef3956252ca8572abf26a666b070e898a6a54b91d4004efdde042"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
