# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"

SRC_URI[md5sum] = "ffbb31b8a0535ac1ac543fb3218667e1"
SRC_URI[sha256sum] = "eac99bc58105747b1411aab2315d8453b0912d4e8ac77eae7c1113b96c208190"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
