# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/imx-parser/imx-parser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=8cf95184c220e247b9917e7244124c5a"

SRC_URI[md5sum] = "4d65f01a6a0454bca6d578e3d05db0c2"
SRC_URI[sha256sum] = "dd9a033865f974d0053fe92f8a2ec903541c08acbbf0100657a43bcf33495500"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7)"
