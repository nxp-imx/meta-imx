# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=102094e9e695888c6a9f9fda9004165d"

SRC_URI[md5sum] = "d78df1acf4d62b4097605a98030311d8"
SRC_URI[sha256sum] = "09ff2f7cf9861c772118940833a55d510bbf8fb125ada8edbf9a09adc90935a4"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7|mx8)"
