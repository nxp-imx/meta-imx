# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=102094e9e695888c6a9f9fda9004165d"

SRC_URI[md5sum] = "84be36b4aff77bfa5e012745f60fa130"
SRC_URI[sha256sum] = "424031e7f7636310be97cbf2c65503976b35a6882d544cb4d574de588c2e6296"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7|mx8)"
