# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"

SRC_URI[md5sum] = "d95e44ac0cc57f6e0b699424245af4e5"
SRC_URI[sha256sum] = "b8025d0098251e49751e9378300bd6eea4c659a5b2f8c870db64a2a56468f27c"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
