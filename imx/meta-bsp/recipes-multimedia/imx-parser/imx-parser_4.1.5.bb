# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=d4f548f93b5fe0ee2bc86758c344412d"

SRC_URI[md5sum] = "658a78106485d5231e5f32a47ff546ca"
SRC_URI[sha256sum] = "d92662167b2e32b2e30af51c98dcbb5480782b821fc83865317e00e06b67a7a1"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7|mx8)"
