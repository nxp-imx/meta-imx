# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=08fd295cce89b0a9c74b9b83ed74f671"

SRC_URI[md5sum] = "60ae98844f59a77169d126be0c33f1a8"
SRC_URI[sha256sum] = "e85e96e24ae8903bf01365a24c7f40737727b1bcce7545cfc03332c52a3a4641"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
