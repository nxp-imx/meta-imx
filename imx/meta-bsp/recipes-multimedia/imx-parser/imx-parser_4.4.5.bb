# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6dfb32a488e5fd6bae52fbf6c7ebb086"

SRC_URI[md5sum] = "ac493c6d4559cd0d5bcdec5dede1d115"
SRC_URI[sha256sum] = "34fc930e018bfc442d5f85417c231cb083cb7aff475ccf0c0e3f4aaa4fb9cab5"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
