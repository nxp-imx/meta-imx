# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=75abe2fa1d16ca79f87cde926f05f72d"

SRC_URI[md5sum] = "684bf37ab4c9b68932f800fb384b36ab"
SRC_URI[sha256sum] = "5b8e3876e5e826ee62ca9839c2b7661453135002d0207bdbd9490175d425f45a"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
