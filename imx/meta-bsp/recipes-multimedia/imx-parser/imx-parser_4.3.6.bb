# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=75abe2fa1d16ca79f87cde926f05f72d"

SRC_URI[md5sum] = "e287361242e15b74a79b7d05305dea57"
SRC_URI[sha256sum] = "fbf82cdfab9788df444da091f20c48e86d5095002b03594c08cc59b9dd6e3db6"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
