# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=08fd295cce89b0a9c74b9b83ed74f671"

SRC_URI[md5sum] = "c853f6c9ede651dfead17c2121140535"
SRC_URI[sha256sum] = "da386ee2aa397a85f62bb65ec1b0e4ebe96249a138c786e8f8b274a8b86f8136"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
