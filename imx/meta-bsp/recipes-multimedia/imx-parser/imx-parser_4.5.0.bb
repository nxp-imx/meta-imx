# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fb0303e4ee8b0e71c094171e2272bd44"

SRC_URI[md5sum] = "b0caecebdac8313a7f3276c24afe72b4"
SRC_URI[sha256sum] = "1d2b37900b342cd4e071dc777348a1229595c76460da8d9932cc7130c34a6aac"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
