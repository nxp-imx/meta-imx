# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5ab1a30d0cd181e3408077727ea5a2db"

SRC_URI[md5sum] = "ba81f02df8b00a31ba29ed812bcaf486"
SRC_URI[sha256sum] = "e3d21a52e7c0671a741941100e3f7297c7c25566b0cdbb7831f21854c20e9683"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
