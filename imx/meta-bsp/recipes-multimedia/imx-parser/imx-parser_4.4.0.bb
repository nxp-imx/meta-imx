# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=75abe2fa1d16ca79f87cde926f05f72d"

SRC_URI[md5sum] = "8200379ec03904d64f607807a9db2f67"
SRC_URI[sha256sum] = "48ed56f47b8c8cfccca17a1a0285c57c2cdef07d771505d41a793df0f580b0d5"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
