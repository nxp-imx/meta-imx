# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5ab1a30d0cd181e3408077727ea5a2db"

SRC_URI[md5sum] = "95f9f29f01b36f505c4040b473e2265a"
SRC_URI[sha256sum] = "d226c25977774d0443dde6a56c9a27991226cecc82eee850985cb84ba8ba57b7"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
