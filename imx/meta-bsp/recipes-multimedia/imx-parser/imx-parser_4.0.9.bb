# Copyright (C) 2013-2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/imx-parser/imx-parser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=8cf95184c220e247b9917e7244124c5a"

SRC_URI[md5sum] = "f2fe811aed1705b420fa351b3fd846a3"
SRC_URI[sha256sum] = "ef877568e5ccda6f089ba93eacb9f5d8e96ea0ce15635d6b837cbec22d2a21be"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7)"
