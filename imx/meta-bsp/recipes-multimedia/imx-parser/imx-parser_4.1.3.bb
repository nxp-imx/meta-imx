# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=102094e9e695888c6a9f9fda9004165d"

SRC_URI[md5sum] = "35ce8a775fb70372eeab274d207f93a6"
SRC_URI[sha256sum] = "cbfdc68830a87f0495f46cad32145b6516f992f3ce446431b29b3a255e699a1e"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7|mx8)"
