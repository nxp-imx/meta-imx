# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=72c0f70181bb6e83eee6aab8de12a9f3" 

SRC_URI[md5sum] = "c0d55767c681c523c26ced4e469c4499"
SRC_URI[sha256sum] = "5511b0d6c266db5621ad727965dd667726bb9d4894fb7476b9fe4183b46e8c22"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
