# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=88595f92466edd79be7f4f9547ffa0ef"

SRC_URI[md5sum] = "b93a470f9bb9223b9605cd5471c17546"
SRC_URI[sha256sum] = "62fa5d6ad84a4ce1b47eeb3e6a60d3966f187477a2326e3d6fd4ad75109d9acd"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
