# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=08fd295cce89b0a9c74b9b83ed74f671"

SRC_URI[md5sum] = "53b4f1e1e21d2503ed1f7684519f37d7"
SRC_URI[sha256sum] = "3cbcfd35f8e8ae87e099ba2d6fd40b2541ad396f3f69f93edcaf8279718b17f0"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
