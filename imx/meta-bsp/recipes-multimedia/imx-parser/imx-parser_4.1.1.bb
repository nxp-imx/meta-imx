# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=102094e9e695888c6a9f9fda9004165d"

SRC_URI[md5sum] = "4c3331eca0177c8c44b4049e2ff4e88b"
SRC_URI[sha256sum] = "ab78359021fd555638d5bb1685d177fecd59bdf2602d22c82740efa6cac82ef2"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx6ul|mx7|mx8)"
