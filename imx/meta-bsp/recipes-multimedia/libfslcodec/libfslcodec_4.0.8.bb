# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslcodec/libfslcodec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=3880bb9c943b135a30fad5e8aabd3ee9"

SRC_URI[md5sum] = "3e5c9ac951af4d7975585a3e390ddd25"
SRC_URI[sha256sum] = "d3d6e6026d216318dabe0149d071564c2b07602102d32e0cbb42abc92100e791"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7|mx6ul)"
