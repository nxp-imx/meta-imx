# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslcodec/libfslcodec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=01ba08a2b77c3a0a9d0ab5d4d83fed64"

SRC_URI[md5sum] = "abe8b7ca0a66d35d2e324821c9137c9c"
SRC_URI[sha256sum] = "4a7ab25ed26eb0897a9572f7237e3df60a10735d11459cb22f9e01a2298e8b14"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7)"
