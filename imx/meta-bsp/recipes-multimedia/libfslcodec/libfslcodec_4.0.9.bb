# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslcodec/libfslcodec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=3880bb9c943b135a30fad5e8aabd3ee9"

SRC_URI[md5sum] = "b235eea9de87bc6f684f07ea229e105d"
SRC_URI[sha256sum] = "8a3186f173df102a8ced621d5e6d878d6fdf26cee414c3b1e399ae47b397c193"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7|mx6ul)"
