# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslcodec/libfslcodec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=01ba08a2b77c3a0a9d0ab5d4d83fed64"

SRC_URI[md5sum] = "ff55eaded809a306ef621e0b09554cae"
SRC_URI[sha256sum] = "b3399fd14a0a8e28e7d08fcc154443cea84700a8074a3429d942aeca3db1d082"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7)"
