# Copyright (C) 2013-2015 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-multimedia/libfslcodec/libfslcodec.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=acdb807ac7275fe32f9f64992e111241"

SRC_URI[md5sum] = "6ba0d4bde61dab60db74a733d778ea2c"
SRC_URI[sha256sum] = "33520df6acaf1c13b565ecf4bd93158babe787e4f51f3c17ecc691c59520ca65"

COMPATIBLE_MACHINE = "(mxs|mx5|mx6|mx7)"
