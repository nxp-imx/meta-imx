SRC_URI_remove = "http://${BPN}.sourcearchive.com/downloads/${PV}-3ubuntu9/${BPN}_${PV}.orig.tar.gz"

SRC_URI_prepend = "https://launchpad.net/ubuntu/+archive/primary/+sourcefiles/${BPN}/${PV}-3ubuntu10.1/${BPN}_${PV}.orig.tar.gz \
"
