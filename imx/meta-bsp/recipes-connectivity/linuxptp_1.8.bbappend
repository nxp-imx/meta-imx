SRC_URI_append = " file://0001-linuxptp-Fix-unknown-type-name-clockid_t.patch"
