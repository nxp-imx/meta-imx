RRECOMMENDS_${PN}-core_append_class-nativesdk = " nativesdk-python3-modules"
