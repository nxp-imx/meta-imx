# Upgrade to support optional cache for eMMC devices

SRCREV = "d0b46442b50794217e53b2455c1344c548d9d088"


