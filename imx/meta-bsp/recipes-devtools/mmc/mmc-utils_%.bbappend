# Upgrade to add more eMMC configure and status check interface

LIC_FILES_CHKSUM = "file://mmc.c;beginline=1;endline=17;md5=f8b01ca0e7a359872d513a2d0bfd0d28"

SRCREV = "bb779acfc385d135b32a6998c1d1fceef0491400"
