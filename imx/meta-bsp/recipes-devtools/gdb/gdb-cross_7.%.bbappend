FILESEXTRAPATHS_prepend := "${THISDIR}/gdb:"

SRC_URI += "file://0001-gdb-fix-the-package-too-long-issue.patch"

