# Copyright 2018 NXP

#Currently only i.MX 8M is supporting OP-TEE addition.
EXTRA_OEMAKE_append_mx8mq = "SPD=opteed"
