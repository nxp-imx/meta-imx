# Copyright (C) 2013-2015 Freescale Semiconductor

require recipes-bsp/imx-vpu/imx-vpu.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=acdb807ac7275fe32f9f64992e111241"

PE = "1"

SRC_URI[md5sum] = "28ea29a7df256cbc968d152c8c19168c"
SRC_URI[sha256sum] = "1c60bc4c437cbe6ca7801fb3905c09e3eb247c535f9738a33d404cdfaad5c7fc"

COMPATIBLE_MACHINE = "(mx6)"
