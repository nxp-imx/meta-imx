# Copyright (C) 2013-2015 Freescale Semiconductor

require recipes-bsp/imx-vpu/imx-vpu.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=acdb807ac7275fe32f9f64992e111241"

PE = "1"

SRC_URI[md5sum] = "350534b393378b95793e97969ef354b8"
SRC_URI[sha256sum] = "f81b6119666fd86485210ddefe1a11f9daf5ff07f53be4a7da8b4dabcda1226a"

COMPATIBLE_MACHINE = "(mx6)"
