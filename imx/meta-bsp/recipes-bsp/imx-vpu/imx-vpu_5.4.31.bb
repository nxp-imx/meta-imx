# Copyright (C) 2013-2015 Freescale Semiconductor

require recipes-bsp/imx-vpu/imx-vpu.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=01ba08a2b77c3a0a9d0ab5d4d83fed64"

PE = "1"

SRC_URI[md5sum] = "e92da5e1b2cc298051d6c48c9be6a260"
SRC_URI[sha256sum] = "7e7db342ff865271ef9e22968bbceb17f49bf95cce3e0edcdb2e8c2243e43abd"

COMPATIBLE_MACHINE = "(mx6)"
