PROVIDES = "virtual/imxvpu"
RPROVIDES_${PN} = "virtual/imxvpu"
