# Copyright (C) 2012-2015 Freescale Semiconductor

require recipes-bsp/firmware-imx/firmware-imx.inc

SRC_URI[md5sum] = "50f669c0b10419e953931bb38aa99acc"
SRC_URI[sha256sum] = "8e39519cad475e61b3c948a9ff493f485425441d982ed5eba790e91727e67f71"

COMPATIBLE_MACHINE = "(mx5|mx6)"
