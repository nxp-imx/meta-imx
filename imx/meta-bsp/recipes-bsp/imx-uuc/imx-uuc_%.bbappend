COMPATIBLE_MACHINE = "(mxs|mx6|mx7)"
