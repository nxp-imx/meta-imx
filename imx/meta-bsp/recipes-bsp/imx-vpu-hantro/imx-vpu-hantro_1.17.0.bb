# Copyright 2017-2019 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"

SRC_URI[md5sum] = "f34a6278e5d77604e8123fe485893c92"
SRC_URI[sha256sum] = "7f9c04df12f4eab81d2b0ca2ef33d697bad48a62074fabe7a34172f60b7ce077"
