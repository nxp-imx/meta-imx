# Copyright 2017-2019 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=fb0303e4ee8b0e71c094171e2272bd44"

SRC_URI[md5sum] = "4150a923f0cf9f6767a4a4f20c157647"
SRC_URI[sha256sum] = "e491b390d8469ce89388e5bfc08c4b82eb300c156d97644805999a38d9b35fca"

COMPATIBLE_MACHINE = "imxvpuhantro"
