# Copyright 2017-2018 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=fb0303e4ee8b0e71c094171e2272bd44"

SRC_URI[md5sum] = "48593116d410ed152d63a9a0ae35524f"
SRC_URI[sha256sum] = "e4bff5ee4c68233428dda4ff33ab890010429fa4d4c7acee43dbdf2600f99018"

COMPATIBLE_MACHINE = "imxvpuhantro"
