# Copyright 2017-2018 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=5ab1a30d0cd181e3408077727ea5a2db"

SRC_URI[md5sum] = "8b2dcd47fdf4922b1f722b0b99ea023b"
SRC_URI[sha256sum] = "4dea4c64ee341ddc45c038d850827dfa5044f643d437d702f43b44fe8a3ea964"

COMPATIBLE_MACHINE = "imxvpuhantro"
