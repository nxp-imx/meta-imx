# Copyright 2017-2019 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3"

SRC_URI[md5sum] = "b707437dd4539622778e93800f42792e"
SRC_URI[sha256sum] = "b596cad59c83bf91e51de0970ac150cccdc48289cfb9dd73d165193807de0a14"
