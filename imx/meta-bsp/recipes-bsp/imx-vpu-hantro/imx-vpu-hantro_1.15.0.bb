# Copyright 2017-2019 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3" 

SRC_URI[md5sum] = "4241af8d38dfa614acdffeadb40dc0ad"
SRC_URI[sha256sum] = "ac6d1600009e73d392eba9e940e96ee815d3903d405f61e0f96f238a26c03c89"

COMPATIBLE_MACHINE = "imxvpuhantro"
