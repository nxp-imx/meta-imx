# Copyright 2017-2019 NXP

require imx-vpu-hantro.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=72c0f70181bb6e83eee6aab8de12a9f3"

SRC_URI[md5sum] = "7cf4845b08915046961323e3b908831c"
SRC_URI[sha256sum] = "2cac5bf06fb6250e9a4ee0cc88f855cb08cf0d353f1f709eac1102b2728e181d"

COMPATIBLE_MACHINE = "imxvpuhantro"
