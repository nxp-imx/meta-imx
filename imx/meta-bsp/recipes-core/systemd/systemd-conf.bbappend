FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0020-logind.conf-Set-HandlePowerKey-to-ignore.patch \
"
