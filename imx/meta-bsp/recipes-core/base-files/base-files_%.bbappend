# Update the file profile

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
