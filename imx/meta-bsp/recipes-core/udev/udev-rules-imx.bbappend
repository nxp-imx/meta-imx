# Update 10-imx.rules 
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

