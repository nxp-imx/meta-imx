inherit fsl-eula2 fsl-eula2-package-arch
