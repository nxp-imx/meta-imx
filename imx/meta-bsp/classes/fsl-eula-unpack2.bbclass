inherit fsl-eula2-unpack2 fsl-eula2-package-arch
