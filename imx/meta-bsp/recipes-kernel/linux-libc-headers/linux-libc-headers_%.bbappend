FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
            file://imx_specific_videodev2_ioctl.patch \
"
