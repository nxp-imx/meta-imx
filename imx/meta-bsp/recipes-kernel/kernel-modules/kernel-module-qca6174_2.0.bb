require kernel-module-qcacld-lea.inc

SUMMARY = "Qualcomm WiFi driver for QCA module 6174"

EXTRA_OEMAKE += "${QCA6174_OEMAKE}"
