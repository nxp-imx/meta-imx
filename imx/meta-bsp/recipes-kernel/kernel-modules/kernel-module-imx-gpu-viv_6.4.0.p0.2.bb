require recipes-kernel/kernel-modules/kernel-module-imx-gpu-viv_6.2.4.p1.8.bb

LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"
SRCBRANCH = "imx_4.19.y"
SRCREV = "b14813c419b1f733c0945e99fc403b7a25774d24"

LOCALVERSION = "-1.1.0"
