require recipes-kernel/kernel-modules/kernel-module-imx-gpu-viv_6.2.4.p1.8.bb

LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"
SRCBRANCH = "imx_4.19.y"
SRCREV = "1cbcc359c114f6ae31542d9d0f87e8d24f44bd5f"
