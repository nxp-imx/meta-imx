require recipes-kernel/kernel-modules/kernel-module-imx-gpu-viv_6.2.4.p4.0.bb

LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"
SRCBRANCH = "imx_4.19.y"
SRCREV = "541f3c2606e9bc5d7c6055cba1fb93b47bfd96d2"

LOCALVERSION = "-1.1.0"
