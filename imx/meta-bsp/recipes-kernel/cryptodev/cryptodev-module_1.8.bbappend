# Copyright (C) 2016 Freescale Semiconductor
# Copyright 2017 NXP
# Released under the MIT license (see COPYING.MIT for the terms)
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://0016-Adjust-to-another-change-in-the-user-page-API.patch \
		"

