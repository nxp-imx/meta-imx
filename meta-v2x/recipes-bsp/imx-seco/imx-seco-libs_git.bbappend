FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRCBRANCH = "master"
SRC_URI_append_mx8dxl = " file://0001-add-v2x_test-to-the-installed-binaries.patch"
SRCREV = "afe4e2fee47d14a33758f20509f0550b0608a463"
