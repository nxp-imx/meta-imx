V2X_PKGS = ""
V2X_PKGS_mx8dxl = "packagegroup-imx-v2x"

CORE_IMAGE_EXTRA_INSTALL += "${V2X_PKGS}"
