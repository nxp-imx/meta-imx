FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-glad-Fix-EGL-loading-for-EGL_NO_DISPLAY-on-EGL-1.5-a.patch"
