# Copyright 2017-2020 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos-2.8.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=1b4db4b25c3a1e422c0c0ed64feb65d2"

SRC_URI[imx7ulp.md5sum] = "b55298ac2f80b1f157ceaae2fd1cb32d"
SRC_URI[imx7ulp.sha256sum] = "a8fbe1180b3d20e933a410cd76e60baac7a9f54e8b2bae8b6b8a3e1af550eca6"

SRC_URI[imx8mm.md5sum] = "0a132f5bc45958eb722c669f4766d079"
SRC_URI[imx8mm.sha256sum] = "500a7d775b5d2af3c3f54f425f0cb3d05dcbf255e7dd7bb38c981ce9010ebec1"

SRC_URI[imx8mq.md5sum] = "bc5df9ad5986fd5fee745a80feb72bb1"
SRC_URI[imx8mq.sha256sum] = "7ed6f251d08e4c6c2fcfe8aef89dc98f3b8cb6e11007c9f3d8073c502e85c054"

SRC_URI[imx8qm.md5sum] = "7bfcad2c582c528aaeb0226598754ab3"
SRC_URI[imx8qm.sha256sum] = "c669de065923753c818f6b3bad0687d1f49eb94ababd076096556815c030a7f3"

SRC_URI[imx8qx.md5sum] = "d9cbcb6a5bf4a9e73399dfa82191670e"
SRC_URI[imx8qx.sha256sum] = "7800cdbebe07f426cdac50b0e295d64215164a767e79ca58bd917445c50e345f"

COMPATIBLE_MACHINE = "(mx7ulp|mx8mm|mx8mq|mx8qm|mx8qxp)"
