# Copyright 2017-2020 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos-2.8.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=228c72f2a91452b8a03c4cab30f30ef9" 

SRC_URI[imx7ulp.md5sum] = "b55298ac2f80b1f157ceaae2fd1cb32d"
SRC_URI[imx7ulp.sha256sum] = "a8fbe1180b3d20e933a410cd76e60baac7a9f54e8b2bae8b6b8a3e1af550eca6"

SRC_URI[imx8dxl.md5sum] = "9a36724501dcc02ff4ed049d78d0d670"
SRC_URI[imx8dxl.sha256sum] = "7034fef347e6db299904921b4326d96805140ca4399f5d7b2e7f4a9c56f5c666"

SRC_URI[imx8mm.md5sum] = "5f70e2a4a4d09ef9ea135636dcffbd73"
SRC_URI[imx8mm.sha256sum] = "2dbfab7fbbe89e89a2881d77c84a6c257699dc73ee6462a813bdd5ad09836b04"

SRC_URI[imx8mq.md5sum] = "baa0a667b19e17a7e55466b92873ad26"
SRC_URI[imx8mq.sha256sum] = "ac88568f63a794530339775a6e49e7928d3d09bcf4ba5edacea1841989e674b0"

SRC_URI[imx8qm.md5sum] = "4d969a6bec76b3f58ca563545135e0a5"
SRC_URI[imx8qm.sha256sum] = "d06a636b84cd559483091cbdb07b5ce9e15a534bca31d4cb756b33b696c2160b"

SRC_URI[imx8qx.md5sum] = "d9cbcb6a5bf4a9e73399dfa82191670e"
SRC_URI[imx8qx.sha256sum] = "7800cdbebe07f426cdac50b0e295d64215164a767e79ca58bd917445c50e345f"

COMPATIBLE_MACHINE = "(mx7ulp|mx8dxl|mx8mm|mx8mq|mx8qm|mx8qxp)"
