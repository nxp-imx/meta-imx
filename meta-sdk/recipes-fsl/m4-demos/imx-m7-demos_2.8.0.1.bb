# Copyright 2019-2020 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos-2.8.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=228c72f2a91452b8a03c4cab30f30ef9" 

SRC_URI[imx8mn.md5sum] = "3beaedc3fde76585551890df2659e61b"
SRC_URI[imx8mn.sha256sum] = "13ce4a19d51e19cfdee9203a943a57637d001840fe546cacb5a5c741e66bbb43"

COMPATIBLE_MACHINE = "(mx8mn)"
