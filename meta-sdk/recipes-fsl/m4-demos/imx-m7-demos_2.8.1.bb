# Copyright 2019-2020 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos-2.8.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=228c72f2a91452b8a03c4cab30f30ef9" 

SRC_URI[imx8mp.md5sum] = "763e009db6013d80a7898101922e12bb"
SRC_URI[imx8mp.sha256sum] = "c57b27d812dc09dee7c2f7a122e6b537aaeaba27660cfea322cfb638484e03b1"

COMPATIBLE_MACHINE = "(mx8mp)"
