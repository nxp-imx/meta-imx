# Replace linux-mfgtool with virtual/kernel

DEPENDS:remove = "linux-mfgtool"
DEPENDS:append = " virtual/kernel"
