#Provide our own rc.local file
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
