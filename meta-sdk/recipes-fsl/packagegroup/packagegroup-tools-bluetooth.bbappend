
RDEPENDS:bluez5:remove = "libasound-module-bluez"
