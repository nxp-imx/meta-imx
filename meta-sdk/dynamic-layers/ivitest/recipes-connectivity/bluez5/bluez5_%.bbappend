RDEPENDS:${PN}-test = "python3-core"
