SRC_URI:remove  = "git://github.com/tesseract-ocr/tessdata.git;branch=master;protocol=https"
SRC_URI:prepend = "git://github.com/tesseract-ocr/tessdata.git;branch=main;protocol=https "
