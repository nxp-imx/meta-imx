# i.MX 95 machine do provide virtual/libgbm required for any drm* flavour
DRM-REMOVE:imxgpu:mx95-nxp-bsp = ""
