FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-CMakeLists.txt-Fix-lib-path-to-work-in-multilib-env.patch"
