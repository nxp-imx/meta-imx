FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://openssl3.patch \
"
