FILESEXTRAPATHS:prepend:imx-nxp-bsp := "${THISDIR}/${PN}:"

# Disable hostapd service when system boot up
INITSCRIPT_NAME = ""
