# FIXME: branch master is renamed to main.

SRC_URI = " \
     git://github.com/opencontainers/runc;branch=main \
     file://0001-Makefile-respect-GOBUILDFLAGS-for-runc-and-remove-re.patch \
     "
