# Enable examples
PACKAGECONFIG_append = " examples"
