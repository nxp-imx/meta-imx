
# Remove dependency on qtgraphicaleffects for sololite
DEPENDS_remove_mx6sl = "qtgraphicaleffects"
RDEPENDS_${PN}_remove_mx6sl = "qtgraphicaleffects-qmlplugins"