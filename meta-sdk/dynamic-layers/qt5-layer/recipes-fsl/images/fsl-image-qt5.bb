DESCRIPTION = "Freescale Image - Adds Qt5"
LICENSE = "MIT"

require dynamic-layers/qt5-layer/recipes-fsl/images/fsl-image-qt5-validation-imx.bb
