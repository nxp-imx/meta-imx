require imx-image-full.bb

IMAGE_FEATURES += "dev-pkgs"
