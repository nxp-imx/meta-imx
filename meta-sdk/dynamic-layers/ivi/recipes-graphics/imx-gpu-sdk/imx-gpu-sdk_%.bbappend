
DEPENDS:append = " wayland-ivi-extension"

BACKEND = "Wayland_IVI"
