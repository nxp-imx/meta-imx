FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-ivi-input-controller-Update-header-path-for-weston-7.patch"
