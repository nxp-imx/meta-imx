
do_install_remove () {
    rmdir ${D}${bindir}
}
