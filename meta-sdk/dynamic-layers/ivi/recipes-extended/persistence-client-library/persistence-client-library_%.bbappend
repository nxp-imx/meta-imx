# Temp fix build with GCC 10
CPPFLAGS += "-Wno-error=stringop-truncation -fcommon -Wno-error=format-extra-args -Wno-error=format="
