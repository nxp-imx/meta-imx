RDEPENDS_${PN}_remove = " \
    bluez5-testtools  \
"

