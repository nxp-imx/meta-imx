
RDEPENDS:${PN}:remove = "audiomanagerplugins"
