
RDEPENDS:${PN}:append = " weston-init"
