RDEPENDS:${PN}:remove = "common-api-c++-someip vsomeip"
