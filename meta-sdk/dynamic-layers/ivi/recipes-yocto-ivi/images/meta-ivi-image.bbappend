IMAGE_FEATURES += "nfs-server ssh-server-openssh tools-debug"
IMAGE_INSTALL:append = " packagegroup-fsl-tools-testapps packagegroup-fsl-tools-gpu"
