DESCRIPTION = "Freescale Image - Adds Qt6"
LICENSE = "MIT"

require dynamic-layers/qt6-layer/recipes-fsl/images/fsl-image-qt6-validation-imx.bb
