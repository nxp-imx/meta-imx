PACKAGECONFIG += "examples"
