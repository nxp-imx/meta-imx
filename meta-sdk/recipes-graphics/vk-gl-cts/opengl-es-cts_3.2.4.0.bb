require ${BPN}.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=67d07a07ec29a50a3ded12b2ba952257"

SRCREV_vk-gl-cts = "9dcb1667286fcae6b8d5a132cdd5e6bad2c896fa"
