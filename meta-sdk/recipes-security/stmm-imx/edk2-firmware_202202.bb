SRCREV_edk2           ?= "b24306f15daa2ff8510b06702114724b33895d3c"
SRCREV_edk2-platforms ?= "c9e377b00fc086fcb5a5b41663a0149bde9bcc2e"

require edk2-firmware.inc
