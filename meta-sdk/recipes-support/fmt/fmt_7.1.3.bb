require recipes-support/fmt/fmt_7.1.0.bb

SRCREV = "7bdf0628b1276379886c7f6dda2cef2b3b374f0b"
