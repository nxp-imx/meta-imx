FILES:${PN} = "/usr/lib ${libdir}"
