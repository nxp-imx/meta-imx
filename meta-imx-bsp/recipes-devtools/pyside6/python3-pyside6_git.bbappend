FILES:${PN} += "\
                /usr/lib/python3.12/site-packages/PySide6 "

