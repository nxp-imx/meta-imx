
SRC_URI:remove = "file://0001-unstable-Add-alpha-compositing-protocol.patch \
                  file://0002-unstable-Add-hdr10-metadata-protocol.patch \
                  file://0003-linux-dmabuf-support-passing-buffer-DTRC-meta-to-com.patch"
