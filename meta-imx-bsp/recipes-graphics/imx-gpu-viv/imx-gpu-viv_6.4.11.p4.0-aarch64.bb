require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac" 

IMX_SRCREV_ABBREV = "032324a"

SRC_URI[sha256sum] = "7d2ff6003527aad94d5ec8f394cadc72e41d162833e48133271bd223f66c3b0c"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
