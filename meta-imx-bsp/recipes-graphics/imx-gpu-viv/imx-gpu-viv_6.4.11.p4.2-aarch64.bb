require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac"

IMX_SRCREV_ABBREV = "39fa7f0"

SRC_URI[sha256sum] = "bfb3996c342749401c0cae406d2582f0064fdd9bd080d7fe7e817e3052b61cd1"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
