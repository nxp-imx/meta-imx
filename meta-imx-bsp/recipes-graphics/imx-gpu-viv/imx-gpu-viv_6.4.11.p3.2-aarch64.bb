require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=c0fb372b5d7f12181de23ef480f225f3"

IMX_SRCREV_ABBREV = "14eeafc"

SRC_URI[sha256sum] = "8f36432eaf09372f4663dc57953f94b397c6c614568fd8da1ad9742bdd448895"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
