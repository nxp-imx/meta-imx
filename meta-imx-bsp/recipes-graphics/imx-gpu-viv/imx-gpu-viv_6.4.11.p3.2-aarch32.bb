require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a93b654673e1bc8398ed1f30e0813359"

IMX_SRCREV_ABBREV = "37e8be5"

SRC_URI[sha256sum] = "6937c6e85f80e89c43363cd103e62eaa7a9a7eb48d9d7332301fc47ec5ea8f6d"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
