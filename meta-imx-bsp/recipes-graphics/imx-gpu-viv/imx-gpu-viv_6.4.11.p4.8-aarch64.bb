require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ef4f968b9dae8ba406390cd617c2301d"

IMX_SRCREV_ABBREV = "fb4c556"

SRC_URI[sha256sum] = "6ba47d30ca480a5e6ad689b5074b3fc39629eae910a6eea646ce2c733e06cd31"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
