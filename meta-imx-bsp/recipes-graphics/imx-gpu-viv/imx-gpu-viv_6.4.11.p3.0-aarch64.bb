require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=c0fb372b5d7f12181de23ef480f225f3" 

IMX_SRCREV_ABBREV = "504697a"

SRC_URI[sha256sum] = "cb50daa91d435ee94351fb8dd008b209f5a8e411c31899c451f499c57f4bbe49"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
