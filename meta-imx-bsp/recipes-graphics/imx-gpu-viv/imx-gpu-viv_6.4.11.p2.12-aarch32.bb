require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ca53281cc0caa7e320d4945a896fb837" 

IMX_SRCREV_ABBREV = "4402ac2"

SRC_URI[sha256sum] = "f7da1312c00a83d18919e646ecb1d6b391a7876f2fa226d9eb1530acfb6ddd21"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
