require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=1142bc333cf4971d6b10bd8292363f02"

IMX_SRCREV_ABBREV = "ecd2e76"

SRC_URI[md5sum] = "c16f9a5bd5d0a7ee8352e1bdcdd8d5e5"
SRC_URI[sha256sum] = "f9c892b3c6d3afe4b982074d8cb74de0acd54dd08ae85ef9c689a58d7565bdfa"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
