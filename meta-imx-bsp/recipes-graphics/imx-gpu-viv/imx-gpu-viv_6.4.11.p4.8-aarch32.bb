require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ef4f968b9dae8ba406390cd617c2301d"

IMX_SRCREV_ABBREV = "087699b"

SRC_URI[sha256sum] = "915664a0e6018c0827bbf6add760c157940c7e0bc80dcb927b83053a0a1ab59e"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
