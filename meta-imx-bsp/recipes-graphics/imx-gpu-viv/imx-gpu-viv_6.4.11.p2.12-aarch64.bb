require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=c0fb372b5d7f12181de23ef480f225f3"

IMX_SRCREV_ABBREV = "37208f1"

SRC_URI[sha256sum] = "ce37a184ac6b1e37b283bcc6767e929c33f688c57ba74c02d7215c7328b919b4"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
