require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=10c0fda810c63b052409b15a5445671a"

IMX_SRCREV_ABBREV = "c65c789"

SRC_URI[md5sum] = "3d3ad9337b3ad7305bc2a05fa472d3e7"
SRC_URI[sha256sum] = "cb18cd665f01c2941c963b2c2f4ee1e02de9ec071a13b02ebf01d5f828231118"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
