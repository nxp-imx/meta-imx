require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ca53281cc0caa7e320d4945a896fb837"

IMX_SRCREV_ABBREV = "8c00f11"

SRC_URI[sha256sum] = "3794b40118a3c7674b20f1fb2731f24ee67c519dc0aa9456e378f88ae4eee30b"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
