require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=44a8052c384584ba09077e85a3d1654f"

IMX_SRCREV_ABBREV = "c56e29e"

SRC_URI[md5sum] = "9fb868fd183a92f7fa6899c9c91fd98c"
SRC_URI[sha256sum] = "4d7a6affa7563c0a27bc4d759d9c9e3f92543518165ce1229c7f49df4143edfb"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
