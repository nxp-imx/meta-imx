require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=2827219e81f28aba7c6a569f7c437fa7" 

IMX_SRCREV_ABBREV = "bc8c0ff"

SRC_URI[md5sum] = "8d0709e2ec1761c0cbde3518024282d5"
SRC_URI[sha256sum] = "3687d55c306f74b6e747f1f0721b95c777e4bb2bc8234b64518cc95ad0c802dd"

COMPATIBLE_MACHINE = "(mx6q-nxp-bsp|mx6dl-nxp-bsp|mx6sx-nxp-bsp|mx6sl-nxp-bsp|mx7ulp-nxp-bsp)"
