require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac" 

IMX_SRCREV_ABBREV = "cb782f4"

SRC_URI[sha256sum] = "c45d6bb2c7df1601af5b7a2877042e45d6456d285e3506aa6429e0b234e46708"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
