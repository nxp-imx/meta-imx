require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a93b654673e1bc8398ed1f30e0813359" 

IMX_SRCREV_ABBREV = "c8d108c"

SRC_URI[sha256sum] = "839c74d42ddd724ee8fe039145aa4058fc23f44a94c1322713a8e4096bf33d4b"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
