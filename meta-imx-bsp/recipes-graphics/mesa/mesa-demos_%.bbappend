FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-YOCIMX-8300-Fix-mesa-demos-build-break-on-GCC-14.patch"
