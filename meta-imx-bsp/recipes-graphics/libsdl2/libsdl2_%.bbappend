PACKAGECONFIG:append = " ${PACKAGECONFIG_LIBDECOR}"
PACKAGECONFIG_LIBDECOR ??= "libdecor"
PACKAGECONFIG_LIBDECOR:mingw32 = ""
