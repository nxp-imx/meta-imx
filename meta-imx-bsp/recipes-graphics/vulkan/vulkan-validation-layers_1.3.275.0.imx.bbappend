FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-custom_containers.h-Fix-build-issues-related-to-GCC-.patch"
