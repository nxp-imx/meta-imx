FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-linker-detect-duplicate-exported-definitions-without.patch"
