FILESEXTRAPATHS:prepend:imx-nxp-bsp := "${COREBASE}/../meta-freescale/recipes-graphics/vulkan/vulkan-loader-1.4.309.0:"
