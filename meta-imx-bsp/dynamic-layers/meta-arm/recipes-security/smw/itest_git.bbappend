# Copyright 2026 NXP
SRCBRANCH = "master"
SRCREV = "33fa180ca86632ca3e903c03c5f0449059513c6d"
