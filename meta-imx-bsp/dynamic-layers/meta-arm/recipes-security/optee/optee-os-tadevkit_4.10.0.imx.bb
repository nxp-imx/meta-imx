require optee-os-tadevkit-imx.inc

SRCBRANCH = "lf_4.10.y"
SRCREV = "020d4a0ef7bae4e12d1f6a0238c3d5968eb35404"
