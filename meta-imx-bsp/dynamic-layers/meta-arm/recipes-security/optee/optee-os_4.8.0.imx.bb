require optee-os-imx.inc

SRCBRANCH = "lf-6.18.2_1.0.0"
SRCREV = "132e6181730f7747916762f332e9c323bed81eee"
