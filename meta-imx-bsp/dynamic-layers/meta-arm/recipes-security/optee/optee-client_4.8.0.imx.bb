require optee-client-imx.inc

SRCBRANCH = "lf-6.18.2_1.0.0"
SRCREV = "9d6f69844ff60ec0966cf3659abcc38eda8b31ea" 
