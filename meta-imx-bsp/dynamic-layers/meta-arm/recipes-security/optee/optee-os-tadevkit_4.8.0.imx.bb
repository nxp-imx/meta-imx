require optee-os-tadevkit-imx.inc

SRCBRANCH = "lf_4.8.y"
SRCREV = "0c9fbdc510f4eb7590eebacf8e373cb3c7caba52"
