require optee-os-imx.inc

SRCBRANCH = "lf-6.18.37_2.1.0"
SRCREV = "6295c1c6c9b6f0bd58a709087c66a78a26a34954"
