require optee-client-imx.inc

SRCBRANCH = "lf_4.10.y"
SRCREV = "7ec3c4bc64b5971077bc5a54a5c270179939a362"
