PACKAGECONFIG:remove = "x11"
