require optee-client-imx.inc

SRCBRANCH = "lf_4.2.y"
SRCREV = "${AUTOREV}"
