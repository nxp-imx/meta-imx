require optee-client-imx.inc

SRCBRANCH = "lf_3.21.y"
SRCREV = "8533e0e6329840ee96cf81b6453f257204227e6c" 
