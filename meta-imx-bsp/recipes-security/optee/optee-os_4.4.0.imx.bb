require optee-os-imx.inc

SRCBRANCH = "lf_4.4.y"
SRCREV = "58b1e5378acfd297b139f75e26b9af43908e17cc"
