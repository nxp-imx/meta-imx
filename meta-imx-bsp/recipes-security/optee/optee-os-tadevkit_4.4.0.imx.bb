require optee-os-tadevkit-imx.inc

SRCBRANCH = "lf_4.4.y"
SRCREV = "a4c055749f5129880cb66c0c0908a5b4295c43dc"
