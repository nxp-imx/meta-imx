require optee-os-imx.inc

SRCBRANCH = "lf_4.6.y"
SRCREV = "b58347ec6ca9c5fcef3e993f5cab2cf9090ed122"
