require optee-os-tadevkit-imx.inc

SRCBRANCH = "lf_4.6.y"
SRCREV = "087ebef33c5b35269c9cc79ce02f8a951b5dfec8"
