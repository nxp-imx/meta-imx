require optee-os-tadevkit-imx.inc

SRCBRANCH = "lf_4.8.y"
SRCREV = "${AUTOREV}"
