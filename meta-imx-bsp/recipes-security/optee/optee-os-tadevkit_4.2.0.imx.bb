require optee-os-tadevkit-imx.inc

SRCBRANCH = "lf_4.2.y"
SRCREV = "84666d0dc0dcbe9dbd3a5fbf59f8112a1a04bbab"
