require optee-client-imx.inc

SRCBRANCH = "lf-6.12.3_1.0.0"
SRCREV = "d221676a58b305bddbf97db00395205b3038de8e" 
