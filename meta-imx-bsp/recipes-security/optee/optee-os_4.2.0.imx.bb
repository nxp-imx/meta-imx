require optee-os-imx.inc

SRCBRANCH = "lf-6.6.23_2.0.0"
SRCREV = "36deec984e125718aae6f11b584908c8a9e436f1"
