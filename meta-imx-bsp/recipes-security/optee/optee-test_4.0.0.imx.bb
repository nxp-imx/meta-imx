require optee-test-imx.inc

SRCBRANCH = "lf_4.0.y"
SRCREV = "95c49d950f50fa774e4530d19a967079b3b61279"
