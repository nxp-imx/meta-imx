require optee-client-imx.inc

SRCBRANCH = "lf-6.12.49_2.2.0"
SRCREV = "9d6f69844ff60ec0966cf3659abcc38eda8b31ea"
