require optee-os-tadevkit-imx.inc

SRCBRANCH = "lf_4.0.y"
SRCREV = "9d6620bd2091e939c4785c62fb9dfe5a93208a99"
