require optee-client-imx.inc

SRCBRANCH = "lf_4.0.y"
SRCREV = "acb0885c117e73cb6c5c9b1dd9054cb3f93507ee"
