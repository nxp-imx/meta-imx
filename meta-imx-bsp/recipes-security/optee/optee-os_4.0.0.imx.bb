require optee-os-imx.inc

SRCBRANCH = "lf_4.0.y"
SRCREV = "ca60cf687c65c69a920fd2e2ea1f4925128a692e"
