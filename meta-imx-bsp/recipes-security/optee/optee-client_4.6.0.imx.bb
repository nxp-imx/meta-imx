require optee-client-imx.inc

SRCBRANCH = "lf_4.6.y"
SRCREV = "${AUTOREV}"
