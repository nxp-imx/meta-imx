require optee-os-imx.inc

SRCBRANCH = "lf_4.8.y"
SRCREV = "${AUTOREV}"
