LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=cd8bc2a79509c22fc9c1782a151210b1"

IMX_SRCREV_ABBREV = "dd94ffe"
SRC_URI[sha256sum] = "1bc2cf35bda1e51f73fe8bc44bb9b58546458daf1b0db70f3244ab742037a423"

