

COMPATIBLE_MACHINE = "(mx943-nxp-bsp|mx952-nxp-bsp|mx937-nxp-bsp)"
