# Pick up the new version for release

SRCBRANCH = "master"
SRCREV = "6ab41c22d5a75575f233f23e910c7b90b3f49b81"
