FILESEXTRAPATHS:prepend := "${THISDIR}/efitools:"
require efitools-native_1.9.2.bb
