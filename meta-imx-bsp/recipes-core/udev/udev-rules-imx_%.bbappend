# Update 10-imx.rules 
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

