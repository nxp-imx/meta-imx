LDFLAGS:append:mx6-nxp-bsp = " -Wl,-z,noexecstack"
LDFLAGS:append:mx7-nxp-bsp = " -Wl,-z,noexecstack"
