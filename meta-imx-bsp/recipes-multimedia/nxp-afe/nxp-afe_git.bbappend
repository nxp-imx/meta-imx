# Copyright 2026 NXP
SRCBRANCH = "MM_04.11.00_2605_L6.18.20"
SRCREV = "7d518eb0b18f7c7faadeb3c3397f8b73f0012f3e" 

RDEPENDS:${PN}:mx8mm-nxp-bsp = " nxp-afe-voiceaec"
RDEPENDS:${PN}:mx8mp-nxp-bsp = " nxp-afe-voiceaec"
RDEPENDS:${PN}:mx91-nxp-bsp = " nxp-afe-voiceaec"
RDEPENDS:${PN}:mx93-nxp-bsp = " nxp-afe-voiceaec"
RDEPENDS:${PN}:mx95-nxp-bsp = " nxp-afe-voiceaec"
