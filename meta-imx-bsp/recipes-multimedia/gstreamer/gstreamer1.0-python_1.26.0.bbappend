DEPENDS:append = " gstreamer1.0-plugins-bad"
