
INSANE_SKIP:${PN}-doc += "buildpaths"
