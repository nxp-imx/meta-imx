include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=c0fb372b5d7f12181de23ef480f225f3"

SRC_URI[sha256sum] = "50d990716bbe8915c3bcd1ee64720e8854e52d67e44c3b7e642ec445a1c9dd60"
IMX_SRCREV_ABBREV = "2f8f5a1"
