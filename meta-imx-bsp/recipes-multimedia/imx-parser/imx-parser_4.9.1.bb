include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ca53281cc0caa7e320d4945a896fb837"

SRC_URI[sha256sum] = "7e45e58ef48e4e419e4462fefa5dc3c2c0f9582526d04043ff440713a2a2143a"
IMX_SRCREV_ABBREV = "24099d3"
