include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac" 

SRC_URI[sha256sum] = "e2314b1369c00c4ea66a41d140390c0b7dc2cee66d82279314bbf189abad9b15"
IMX_SRCREV_ABBREV = "7ab6273"
