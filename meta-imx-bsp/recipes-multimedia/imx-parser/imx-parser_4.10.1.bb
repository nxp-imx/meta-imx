include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=a93b654673e1bc8398ed1f30e0813359" 

SRC_URI[sha256sum] = "5e843831cd7294f9708d56446b7a7e8ab107c30dd0d9721c2ed73eaf0bcb8446"
IMX_SRCREV_ABBREV = "bc73865"
