include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=10c0fda810c63b052409b15a5445671a" 

SRC_URI[md5sum] = "a5ed610aa3b5c6883988cec99fdce7ba"
SRC_URI[sha256sum] = "2e556cfcf0e8afda13dbe5c29ece1e37a096adee4c8bfb68f64ae67789e55692"
