include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cf2070b16b9d4acf60a98e8cbc32a25a"

SRC_URI[sha256sum] = "2010bb52e3495c6fd8d582d486ef674ec4261a1123d9c22e6182bfddbfbff0a0"
IMX_SRCREV_ABBREV = "e8a7ec7"
