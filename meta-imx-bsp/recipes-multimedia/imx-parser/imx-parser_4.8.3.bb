include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=2827219e81f28aba7c6a569f7c437fa7" 

SRC_URI[md5sum] = "1d36def0b37fd7b95aeda7830f0c9734"
SRC_URI[sha256sum] = "26088167c737ec80b4906aacc9a5c58db0481673860b0960f8bcf26d37cbb634"
