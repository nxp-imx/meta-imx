include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=44a8052c384584ba09077e85a3d1654f" 

SRC_URI[md5sum] = "e6d60270978e4605e6c6031f35e45ea7"
SRC_URI[sha256sum] = "75397660f9c634223293e571bb1d5d2120daecf31320cf207c9a8826ad2a9012"
