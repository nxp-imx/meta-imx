include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac" 

SRC_URI[sha256sum] = "04cdb91f7f2e0d4afb264972aaa263ecf1be4a66e29b16925b0f311afc3f3615"
IMX_SRCREV_ABBREV = "ec08e84"
