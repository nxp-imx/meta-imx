include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=c0fb372b5d7f12181de23ef480f225f3"

SRC_URI[sha256sum] = "3b91376bbe023b80813515f5699d4974b335f041be4214d26c709cc09d1aca24"
IMX_SRCREV_ABBREV = "5239d12"
