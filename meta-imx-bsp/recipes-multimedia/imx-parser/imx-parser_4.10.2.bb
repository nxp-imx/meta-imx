include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac" 

SRC_URI[sha256sum] = "53c2bb623fd790917876113b03ae2b01bcea9b7e9076f95585281380221de740"
IMX_SRCREV_ABBREV = "be29e3c"
