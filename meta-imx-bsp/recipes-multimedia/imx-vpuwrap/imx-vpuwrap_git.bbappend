# Copyright 2026 NXP
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=6f862c6751ebcaa393467694c7b0c69a"


SRCBRANCH = "MM_04.11.01_2608_L6.18.37"
SRCREV = "15c98d82384589d5e7902b8e3701af19b490c5f2"
