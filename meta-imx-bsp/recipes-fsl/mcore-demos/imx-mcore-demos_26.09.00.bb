# Copyright 2026 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx943-nxp-bsp = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac"

SRC_URI[imx943.sha256sum] = "c392c60c9128599b479205cdb2690eb1a82b8c4897ef72b98d9fce0905c25a8b"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp)"
