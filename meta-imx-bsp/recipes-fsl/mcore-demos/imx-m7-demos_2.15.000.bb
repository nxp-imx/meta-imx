# Copyright 2023 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx95-nxp-bsp = "file://COPYING;md5=44a8052c384584ba09077e85a3d1654f"

SRC_URI[imx95.md5sum] = "111322759899931db68072bffd043664"
SRC_URI[imx95.sha256sum] = "48388a61bb4fa9cc1490fb4a14f104e74022f5c8ec987e4ea3ed7eb2c66d44bf"

COMPATIBLE_MACHINE = "(mx95-nxp-bsp)"
