# Copyright 2023-2025 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx93-nxp-bsp = "file://COPYING;md5=cf2070b16b9d4acf60a98e8cbc32a25a"

SRC_URI[imx93.sha256sum] = "f862f7817a3242662ba1de95f76f223a92679683f69ad0b94b6a15bedb52027e"

COMPATIBLE_MACHINE = "(mx93-nxp-bsp)"

