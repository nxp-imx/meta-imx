# Copyright 2023-2024 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx95-nxp-bsp = "file://COPYING;md5=ca53281cc0caa7e320d4945a896fb837" 

SRC_URI[imx95.sha256sum] = "63a1f77dd94d15a03d2ba31769d9e1f31b88354000662e9a7dfaa85aec86349d"

COMPATIBLE_MACHINE = "(mx95-nxp-bsp)"
