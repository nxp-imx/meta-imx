# Copyright 2023-2025 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx95-nxp-bsp = "file://COPYING;md5=a93b654673e1bc8398ed1f30e0813359"

SRC_URI[imx95.sha256sum] = "6c427982072b2bd4c6243126a4562a8f5bcb681a72747c018db2b242671cb010"

COMPATIBLE_MACHINE = "(mx95-nxp-bsp)"

