# Copyright 2025 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx943-nxp-bsp = "file://COPYING;md5=c0fb372b5d7f12181de23ef480f225f3"

SRC_URI[imx943.sha256sum] = "6f01e4b10f43048c6b4c5d55fea286f1a8cfd83ef6449452bd6b90551bafeaab"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp)"
