# Copyright 2026 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx937-nxp-bsp = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac"
SRC_URI[imx937.sha256sum] = "1de744428d225ec256a7f95e6339b213ca05841d361c33b92c421d979d332648"

COMPATIBLE_MACHINE = "(mx937-generic-bsp)"
