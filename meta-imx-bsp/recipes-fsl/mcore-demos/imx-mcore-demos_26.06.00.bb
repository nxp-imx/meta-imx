# Copyright 2026 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx943-nxp-bsp = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac" 

SRC_URI[imx943.sha256sum] = "405ffe0c7544fa22a4531bf70ae36fcc57f6c5ecbfbd81d8812a7deb7a754964"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp)"
