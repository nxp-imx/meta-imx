# Copyright 2025 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx943-nxp-bsp = "file://COPYING;md5=c0fb372b5d7f12181de23ef480f225f3" 

SRC_URI[imx943.sha256sum] = "e0ccf0c83399127556dd3dfa6b472bc269ecf2a579f0ad26947a7b325b44d8ce"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp)"
