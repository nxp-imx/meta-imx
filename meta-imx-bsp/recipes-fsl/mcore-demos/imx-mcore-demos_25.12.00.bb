# Copyright 2025 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx943-nxp-bsp = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac" 

SRC_URI[imx943.sha256sum] = "20847913431a7c557af0ba5ece919865cd54a094861ae3ef65fa6562c30ecb1e"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp)"
