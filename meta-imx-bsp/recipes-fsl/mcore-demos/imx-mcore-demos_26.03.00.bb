# Copyright 2025-2026 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx943-nxp-bsp = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac"

SRC_URI[imx943.sha256sum] = "e48e586f71668198a406203d3868a2f3a73f2820603260cc3b47730c54c4a1e2"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp)"
