# Copyright 2023 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx93-nxp-bsp = "file://COPYING;md5=44a8052c384584ba09077e85a3d1654f"


SRC_URI[imx93.md5sum] = "473674800105643f5d300af9662c1fc0"
SRC_URI[imx93.sha256sum] = "c9cdf2d4e15d4d76f392b1183c13d7a7069ea217aa35e156c3885dac59ddc4f9"

COMPATIBLE_MACHINE = "(mx93-nxp-bsp)"
