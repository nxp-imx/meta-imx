# Copyright 2025 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx943-nxp-bsp = "file://COPYING;md5=bc649096ad3928ec06a8713b8d787eac"

SRC_URI[imx943.sha256sum] = "12277e80c1fedc7a751ec835c5f82157caf528f231e7313186a0bf6378c1362d"

COMPATIBLE_MACHINE = "(mx943-nxp-bsp)"
