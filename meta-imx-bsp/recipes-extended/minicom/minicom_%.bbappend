FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-fix-baudrate-setting-on-glibc-2.42.patch"
