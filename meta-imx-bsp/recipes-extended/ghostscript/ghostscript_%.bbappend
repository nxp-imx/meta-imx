
CFLAGS += " -Wno-error=declaration-after-statement"
