INSANE_SKIP:${PN} += "buildpaths"
