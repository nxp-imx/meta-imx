PACKAGECONFIG:append = "jevents"
