inherit distutils3backport

DEPENDS += "python3-setuptools-native"

