require nnstreamer.inc

SRCREV = "985535252742c881e3ba52b33946de8e55cf7a51"
PV .= "+git${SRCPV}"
