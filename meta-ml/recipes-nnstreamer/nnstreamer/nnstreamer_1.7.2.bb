require nnstreamer.inc

SRCREV = "7f65d754534a5464725d561e65a0fa49480a82ea"
PV .= "+git${SRCPV}"
