require nnshark.inc

SRCREV = "9ec032bbff46ee9b5a124dce07d2d2ee58ee4381"
PV .= "+git${SRCPV}"
