require nnshark.inc

SRCREV = "b2943cdda24f23586ea82c3bf735cfa6a9045f59"
PV .= "+git${SRCPV}"
