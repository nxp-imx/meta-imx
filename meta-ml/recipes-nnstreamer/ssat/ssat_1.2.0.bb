require ssat.inc

SRCREV = "163516897314d6e0c437a84272e348f278038be3"
PV .= "+git${SRCPV}"
