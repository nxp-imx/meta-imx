SRC_URI_remove = "git://github.com/protocolbuffers/protobuf.git "
SRC_URI_append =  "git://github.com/protocolbuffers/protobuf.git;protocol=https;nobranch=1"
