# Copyright 2021 NXP
require ${BPN}.inc

SRC_URI += "file://0001-configure-use-pkg-config-for-pcre-detection.patch \
           "
SRC_URI[md5sum] = "7c3e46cb5af2b469722cafa0d91e127b"
SRC_URI[sha256sum] = "d53be9730d8d58a16bf0cbd1f8ac0c0c3e1090573168bfa151b01eb47fa906fc"
