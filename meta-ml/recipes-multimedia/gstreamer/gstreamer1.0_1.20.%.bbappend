PACKAGECONFIG:append:mx8m-nxp-bsp = " tracer-hooks"
