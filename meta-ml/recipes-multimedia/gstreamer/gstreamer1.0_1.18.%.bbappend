PACKAGECONFIG_append_mx8m = " tracer-hooks"
